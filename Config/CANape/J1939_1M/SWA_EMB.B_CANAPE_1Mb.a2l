ASAP2_VERSION 1 70
/begin PROJECT TEST_PROJECT "TEST_PROJECT"
/begin HEADER "TEST_PROJECT" PROJECT_NO D0 VERSION "3095.02" /end HEADER
/begin MODULE TEST_PROJECT "TestSupplier"
/begin MOD_COMMON "" DEPOSIT ABSOLUTE BYTE_ORDER MSB_LAST ALIGNMENT_BYTE 1 ALIGNMENT_WORD 2 ALIGNMENT_LONG 4 ALIGNMENT_INT64 1 ALIGNMENT_FLOAT32_IEEE 4 ALIGNMENT_FLOAT64_IEEE 8 /end MOD_COMMON
/begin RECORD_LAYOUT DATA_RECORD_UBYTE FNC_VALUES 1 UBYTE ROW_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT DATA_RECORD_SBYTE FNC_VALUES 1 SBYTE ROW_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT DATA_RECORD_UWORD FNC_VALUES 1 UWORD ROW_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT DATA_RECORD_SWORD FNC_VALUES 1 SWORD ROW_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT DATA_RECORD_ULONG FNC_VALUES 1 ULONG ROW_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT DATA_RECORD_FLOAT32_IEEE FNC_VALUES 1 FLOAT32_IEEE ROW_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT AXIS_PTS_X_FLOAT32_IEEE_VEMS AXIS_PTS_X 1 FLOAT32_IEEE INDEX_INCR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT AXIS_PTS_X_FLOAT64_IEEE_VEMS AXIS_PTS_X 1 FLOAT64_IEEE INDEX_INCR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT AXIS_PTS_X_UBYTE NO_AXIS_PTS_X 1 UBYTE AXIS_PTS_X 2 UBYTE INDEX_INCR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT AXIS_PTS_X_SBYTE NO_AXIS_PTS_X 1 SBYTE AXIS_PTS_X 2 SBYTE INDEX_INCR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT AXIS_PTS_X_UWORD NO_AXIS_PTS_X 1 UWORD AXIS_PTS_X 2 UWORD INDEX_INCR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT AXIS_PTS_X_SWORD NO_AXIS_PTS_X 1 SWORD AXIS_PTS_X 2 SWORD INDEX_INCR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT AXIS_PTS_X_ULONG NO_AXIS_PTS_X 1 ULONG AXIS_PTS_X 2 ULONG INDEX_INCR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT AXIS_PTS_X_SLONG NO_AXIS_PTS_X 1 SLONG AXIS_PTS_X 2 SLONG INDEX_INCR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT AXIS_PTS_X_FLOAT32_IEEE NO_AXIS_PTS_X 1 FLOAT32_IEEE AXIS_PTS_X 2 FLOAT32_IEEE INDEX_INCR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT AXIS_PTS_X_FLOAT64_IEEE NO_AXIS_PTS_X 1 FLOAT64_IEEE AXIS_PTS_X 2 FLOAT64_IEEE INDEX_INCR DIRECT /end RECORD_LAYOUT
/begin CHARACTERISTIC BTT6020_kf32HsdOcFltLsdCrntThd "BTT6020_kf32HsdOcFltLsdCrntThd" VALUE 0x800289E8 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p0_6 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC BTT6020_kf32LsdScFltThd "BTT6020_kf32LsdScFltThd" VALUE 0x800289EC DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p0_6 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SPDSNSRSIRSETN_u8DirCtrl "Control the speed sensor direction dectection, this can reverst direction." VALUE 0x800286E3 DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbDioWrSolenoidHsCmd2 "Change output state" VALUE 0x80028351 DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbDioWrSolenoidHsCmd3 "Change output state" VALUE 0x80028350 DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbDioWrSolenoidHsCmd4 "Change output state" VALUE 0x8002834F DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbDioWrSolenoidHsDen1 "Change Diagnosis Enable state" VALUE 0x8002834E DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbDioWrSolenoidHsDen2 "Change Diagnosis Enable state" VALUE 0x8002834D DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbDioWrSolenoidHsDen3 "Change Diagnosis Enable state" VALUE 0x8002834C DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbDioWrSolenoidHsDen4 "Change Diagnosis Enable state" VALUE 0x8002834B DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbDioWrSupplyWdi "Change output state" VALUE 0x8002834A DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbEVPTstEnaC "Activate EVP tests" VALUE 0x80028349 DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbFimTstEnaC "Activate Tle62X0 tests" VALUE 0x80028348 DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbPwmTstEnaC "Activate Dio tests" VALUE 0x80028347 DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbSftyTstEnaC "Activate Tle62X0 tests" VALUE 0x80028346 DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbTLE8242TstEnaC "Activate Tle62X0 tests" VALUE 0x80028338 DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbTle62X0TstEnaC "Activate Tle62X0 tests" VALUE 0x80028345 DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbTle62X0WrOutLsd1 "Activate Tle62X0 output" VALUE 0x80028344 DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbTle62X0WrOutLsd10 "Activate Tle62X0 output" VALUE 0x80028343 DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbTle62X0WrOutLsd11 "Activate Tle62X0 output" VALUE 0x80028342 DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbTle62X0WrOutLsd12 "Activate Tle62X0 output" VALUE 0x80028341 DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbTle62X0WrOutLsd2 "Activate Tle62X0 output" VALUE 0x80028340 DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbTle62X0WrOutLsd3 "Activate Tle62X0 output" VALUE 0x8002833F DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbTle62X0WrOutLsd4 "Activate Tle62X0 output" VALUE 0x8002833E DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbTle62X0WrOutLsd5 "Activate Tle62X0 output" VALUE 0x8002833D DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbTle62X0WrOutLsd6 "Activate Tle62X0 output" VALUE 0x8002833C DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbTle62X0WrOutLsd7 "Activate Tle62X0 output" VALUE 0x8002833B DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbTle62X0WrOutLsd8 "Activate Tle62X0 output" VALUE 0x8002833A DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbTle62X0WrOutLsd9 "Activate Tle62X0 output" VALUE 0x80028339 DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbTrimTstEnaC "Activate Tle62X0 tests" VALUE 0x80028337 DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbWdgTstEnaC "Activate Tle62X0 tests" VALUE 0x80028336 DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrEbc1Sa03BrakePedalPos "SWTST_kf32ComWrEbc1Sa03BrakePedalPos" VALUE 0x800285D4 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrEbc1Sa03EngRetarderSelection "SWTST_kf32ComWrEbc1Sa03EngRetarderSelection" VALUE 0x800285D0 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrErc1Sa16ActlMxAvlblRetarderPercentTorque "SWTST_kf32ComWrErc1Sa16ActlMxAvlblRetarderPercentTorque" VALUE 0x800285CC DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrErc1Sa16ActualRetarderPercentTorque "SWTST_kf32ComWrErc1Sa16ActualRetarderPercentTorque" VALUE 0x800285C8 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrErc1Sa16DrvrsDemandRetarderPercentTorque "SWTST_kf32ComWrErc1Sa16DrvrsDemandRetarderPercentTorque" VALUE 0x800285C4 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrErc1Sa16IntendedRetarderPercentTorque "SWTST_kf32ComWrErc1Sa16IntendedRetarderPercentTorque" VALUE 0x800285C0 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrErc1Sa16RetarderSelectionNonengine "SWTST_kf32ComWrErc1Sa16RetarderSelectionNonengine" VALUE 0x800285BC DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrEtc1Sa03PercentClutchSlip "SWTST_kf32ComWrEtc1Sa03PercentClutchSlip" VALUE 0x800285B8 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrEtc1Sa03TransInputShaftSpeed "SWTST_kf32ComWrEtc1Sa03TransInputShaftSpeed" VALUE 0x800285B4 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrEtc1Sa03TransOutputShaftSpeed "SWTST_kf32ComWrEtc1Sa03TransOutputShaftSpeed" VALUE 0x800285B0 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrEtc2Sa03TransActualGearRatio "SWTST_kf32ComWrEtc2Sa03TransActualGearRatio" VALUE 0x800285AC DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrEtc8Sa03TransClutchConverterInputSpeed "SWTST_kf32ComWrEtc8Sa03TransClutchConverterInputSpeed" VALUE 0x800285A8 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrEtc8Sa03TransTorqueConverterRatio "SWTST_kf32ComWrEtc8Sa03TransTorqueConverterRatio" VALUE 0x800285A4 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrRcSa16MaxRetarderSpeedPoint2 "SWTST_kf32ComWrRcSa16MaxRetarderSpeedPoint2" VALUE 0x800285A0 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrRcSa16PercentTorqueAtIdlePoint1 "SWTST_kf32ComWrRcSa16PercentTorqueAtIdlePoint1" VALUE 0x8002859C DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrRcSa16PercentTorqueAtMaxSpeedPoint2 "SWTST_kf32ComWrRcSa16PercentTorqueAtMaxSpeedPoint2" VALUE 0x80028598 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrRcSa16PercentTorqueAtPeakTorquePoint5 "SWTST_kf32ComWrRcSa16PercentTorqueAtPeakTorquePoint5" VALUE 0x80028594 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrRcSa16PercentTorqueAtPoint3 "SWTST_kf32ComWrRcSa16PercentTorqueAtPoint3" VALUE 0x80028590 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrRcSa16PercentTorqueAtPoint4 "SWTST_kf32ComWrRcSa16PercentTorqueAtPoint4" VALUE 0x8002858C DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrRcSa16ReferenceRetarderTorque "SWTST_kf32ComWrRcSa16ReferenceRetarderTorque" VALUE 0x80028588 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrRcSa16RetarderSpeedAtIdlePoint1 "SWTST_kf32ComWrRcSa16RetarderSpeedAtIdlePoint1" VALUE 0x80028584 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrRcSa16RetarderSpeedAtPeakTorquePoint5 "SWTST_kf32ComWrRcSa16RetarderSpeedAtPeakTorquePoint5" VALUE 0x80028580 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrRcSa16RetarderSpeedAtPoint3 "SWTST_kf32ComWrRcSa16RetarderSpeedAtPoint3" VALUE 0x8002857C DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrRcSa16RetarderSpeedAtPoint4 "SWTST_kf32ComWrRcSa16RetarderSpeedAtPoint4" VALUE 0x80028578 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrRfSa16HydRetarderOilTemp "SWTST_kf32ComWrRfSa16HydRetarderOilTemp" VALUE 0x80028574 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrRfSa16HydRetarderPress "SWTST_kf32ComWrRfSa16HydRetarderPress" VALUE 0x80028570 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrRfSa16RetarderCoolantOutletTemp "SWTST_kf32ComWrRfSa16RetarderCoolantOutletTemp" VALUE 0x8002856C DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrTcfg2Sa03TransTorqueLimit "SWTST_kf32ComWrTcfg2Sa03TransTorqueLimit" VALUE 0x80028568 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrTcfgSa03NumberOfForwardGearRatios "SWTST_kf32ComWrTcfgSa03NumberOfForwardGearRatios" VALUE 0x80028564 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrTcfgSa03NumberOfReverseGearRatios "SWTST_kf32ComWrTcfgSa03NumberOfReverseGearRatios" VALUE 0x80028560 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrTcfgSa03TransGearRatio "SWTST_kf32ComWrTcfgSa03TransGearRatio" VALUE 0x8002855C DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrTrf1Sa03ClutchPress "SWTST_kf32ComWrTrf1Sa03ClutchPress" VALUE 0x80028558 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrTrf1Sa03TransFilterDiffPress "SWTST_kf32ComWrTrf1Sa03TransFilterDiffPress" VALUE 0x80028554 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrTrf1Sa03TransOilLevel1 "SWTST_kf32ComWrTrf1Sa03TransOilLevel1" VALUE 0x80028550 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrTrf1Sa03TransOilLevel1HighLow "SWTST_kf32ComWrTrf1Sa03TransOilLevel1HighLow" VALUE 0x8002854C DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrTrf1Sa03TransOilPress "SWTST_kf32ComWrTrf1Sa03TransOilPress" VALUE 0x80028548 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrTrf1Sa03TransOilTemp1 "SWTST_kf32ComWrTrf1Sa03TransOilTemp1" VALUE 0x80028544 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrTrf2Sa03TransOilLevel2HighLow "SWTST_kf32ComWrTrf2Sa03TransOilLevel2HighLow" VALUE 0x80028540 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrTrf2Sa03TransOilLifeRemaining "SWTST_kf32ComWrTrf2Sa03TransOilLifeRemaining" VALUE 0x8002853C DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrTrf2Sa03TransOilTemp2 "SWTST_kf32ComWrTrf2Sa03TransOilTemp2" VALUE 0x80028538 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrTrf2Sa03TrnsTorqueConverterOilOutletTemp "SWTST_kf32ComWrTrf2Sa03TrnsTorqueConverterOilOutletTemp" VALUE 0x80028534 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrTsc1Sa03EngRequestedSpeedSpeedLimit "SWTST_kf32ComWrTsc1Sa03EngRequestedSpeedSpeedLimit" VALUE 0x80028530 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrTsc1Sa03EngRequestedTorqueHighResolution "SWTST_kf32ComWrTsc1Sa03EngRequestedTorqueHighResolution" VALUE 0x8002852C DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrTsc1Sa03EngRequestedTorqueTorqueLimit "SWTST_kf32ComWrTsc1Sa03EngRequestedTorqueTorqueLimit" VALUE 0x80028528 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrTxDBStaMCU1Sa240TxDBTempMCU "SWTST_kf32ComWrTxDBStaMCU1Sa240TxDBTempMCU" VALUE 0x80028524 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrTxDBStaMCU1Sa240TxDBTempMot "SWTST_kf32ComWrTxDBStaMCU1Sa240TxDBTempMot" VALUE 0x80028520 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrTxDBStaMCU2Sa240TxDBPowerMot "SWTST_kf32ComWrTxDBStaMCU2Sa240TxDBPowerMot" VALUE 0x8002851C DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrTxDBStaMCU2Sa240TxDBTrqMot "SWTST_kf32ComWrTxDBStaMCU2Sa240TxDBTrqMot" VALUE 0x80028518 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrTxDBStaVCU1Sa208TxDBVehVelocity "SWTST_kf32ComWrTxDBStaVCU1Sa208TxDBVehVelocity" VALUE 0x80028514 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrTxDBStaVCU2Sa208TxDBAccPedlPos "SWTST_kf32ComWrTxDBStaVCU2Sa208TxDBAccPedlPos" VALUE 0x80028510 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrTxDBStaVCU2Sa208TxDBBrakPedlPos "SWTST_kf32ComWrTxDBStaVCU2Sa208TxDBBrakPedlPos" VALUE 0x8002850C DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrTxDBStaVCU2Sa208TxDBDistancePerCharge "SWTST_kf32ComWrTxDBStaVCU2Sa208TxDBDistancePerCharge" VALUE 0x80028508 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrTxDBStaVCU2Sa208TxDBVcuVersion "SWTST_kf32ComWrTxDBStaVCU2Sa208TxDBVcuVersion" VALUE 0x80028504 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrTxMCUCmdSa208TxMCULimitHigh "SWTST_kf32ComWrTxMCUCmdSa208TxMCULimitHigh" VALUE 0x80028500 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrTxMCUCmdSa208TxMCULimitLow "SWTST_kf32ComWrTxMCUCmdSa208TxMCULimitLow" VALUE 0x800284FC DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrTxMCUCmdSa208TxMCUMotTargetSpd "SWTST_kf32ComWrTxMCUCmdSa208TxMCUMotTargetSpd" VALUE 0x800284F8 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrTxMCUCmdSa208TxMCUMotTargetTrq "SWTST_kf32ComWrTxMCUCmdSa208TxMCUMotTargetTrq" VALUE 0x800284F4 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kf32ComWrTxMultCtrlSa208TxMultCtrlCANGivenSpd "SWTST_kf32ComWrTxMultCtrlSa208TxMultCtrlCANGivenSpd" VALUE 0x800284F0 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ks8ComWrEtc2Sa03TransCurrentGear "SWTST_ks8ComWrEtc2Sa03TransCurrentGear" VALUE 0x800284CC DATA_RECORD_SBYTE 255 I_5 -128 127 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ks8ComWrEtc2Sa03TransSelectedGear "SWTST_ks8ComWrEtc2Sa03TransSelectedGear" VALUE 0x800284CB DATA_RECORD_SBYTE 255 I_5 -128 127 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ks8ComWrEtc7Sa03TransRequestedGearFeedback "SWTST_ks8ComWrEtc7Sa03TransRequestedGearFeedback" VALUE 0x800284CA DATA_RECORD_SBYTE 255 I_5 -128 127 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku16ComWrEtc2Sa03TransCurrentRange "SWTST_ku16ComWrEtc2Sa03TransCurrentRange" VALUE 0x800280CA DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku16ComWrEtc2Sa03TransRequestedRange "SWTST_ku16ComWrEtc2Sa03TransRequestedRange" VALUE 0x800280C8 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku16ComWrTxDBStaMCU1Sa240TxDBBusVolt "SWTST_ku16ComWrTxDBStaMCU1Sa240TxDBBusVolt" VALUE 0x800280C6 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku16ComWrTxDBStaMCU2Sa240TxDBSpdMot "SWTST_ku16ComWrTxDBStaMCU2Sa240TxDBSpdMot" VALUE 0x800280C4 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8AdcTstNrC "Test number" VALUE 0x80028335 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8Btt6020TstNrC "Test number" VALUE 0x80028334 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8CalibTstNrC "Test number" VALUE 0x80028333 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComTstNrC "Test number" VALUE 0x80028332 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrCiSa03CptIdn "SWTST_ku8ComWrCiSa03CptIdn" CURVE 0x8002826A DATA_RECORD_UBYTE 255 I_5 0 255
 /begin AXIS_DESCR FIX_AXIS NO_INPUT_QUANTITY Id_0x00 200 0 199 MAX_GRAD 100.0 FIX_AXIS_PAR_DIST 0 1 200 /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEbc1Sa03ABSEBSAmberWarningSignal "SWTST_ku8ComWrEbc1Sa03ABSEBSAmberWarningSignal" VALUE 0x80028269 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEbc1Sa03ABSFullyOperational "SWTST_ku8ComWrEbc1Sa03ABSFullyOperational" VALUE 0x80028268 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEbc1Sa03ABSOffroadSwitch "SWTST_ku8ComWrEbc1Sa03ABSOffroadSwitch" VALUE 0x80028267 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEbc1Sa03ASRBrakeCtrlActive "SWTST_ku8ComWrEbc1Sa03ASRBrakeCtrlActive" VALUE 0x80028264 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEbc1Sa03ASREngCtrlActive "SWTST_ku8ComWrEbc1Sa03ASREngCtrlActive" VALUE 0x80028263 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEbc1Sa03ASRHillHolderSwitch "SWTST_ku8ComWrEbc1Sa03ASRHillHolderSwitch" VALUE 0x80028262 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEbc1Sa03ASROffroadSwitch "SWTST_ku8ComWrEbc1Sa03ASROffroadSwitch" VALUE 0x80028261 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEbc1Sa03ATCASRInformationSignal "SWTST_ku8ComWrEbc1Sa03ATCASRInformationSignal" VALUE 0x80028260 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEbc1Sa03AccelInterlockSwitch "SWTST_ku8ComWrEbc1Sa03AccelInterlockSwitch" VALUE 0x80028266 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEbc1Sa03AntiLockBrakingActive "SWTST_ku8ComWrEbc1Sa03AntiLockBrakingActive" VALUE 0x80028265 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEbc1Sa03EBSBrakeSwitch "SWTST_ku8ComWrEbc1Sa03EBSBrakeSwitch" VALUE 0x8002825F DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEbc1Sa03EBSRedWarningSignal "SWTST_ku8ComWrEbc1Sa03EBSRedWarningSignal" VALUE 0x8002825E DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEbc1Sa03EngAuxShutdownSwitch "SWTST_ku8ComWrEbc1Sa03EngAuxShutdownSwitch" VALUE 0x8002825D DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEbc1Sa03EngDerateSwitch "SWTST_ku8ComWrEbc1Sa03EngDerateSwitch" VALUE 0x8002825C DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEbc1Sa03HaltBrakeSwitch "SWTST_ku8ComWrEbc1Sa03HaltBrakeSwitch" VALUE 0x8002825B DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEbc1Sa03RemoteAccelEnableSwitch "SWTST_ku8ComWrEbc1Sa03RemoteAccelEnableSwitch" VALUE 0x8002825A DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEbc1Sa03SrcAddrssOfCntrllngDvcFrBrkeCtrl "SWTST_ku8ComWrEbc1Sa03SrcAddrssOfCntrllngDvcFrBrkeCtrl" VALUE 0x80028259 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEbc1Sa03TractionCtrlOverrideSwitch "SWTST_ku8ComWrEbc1Sa03TractionCtrlOverrideSwitch" VALUE 0x80028258 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEbc1Sa03TrailerABSStatus "SWTST_ku8ComWrEbc1Sa03TrailerABSStatus" VALUE 0x80028257 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEbc1Sa03TrctrMntdTrailerABSWarningSignal "SWTST_ku8ComWrEbc1Sa03TrctrMntdTrailerABSWarningSignal" VALUE 0x80028256 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrErc1Sa16EngCoolantLoadIncrease "SWTST_ku8ComWrErc1Sa16EngCoolantLoadIncrease" VALUE 0x80028255 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrErc1Sa16RetarderEnableBrakeAssistSwitch "SWTST_ku8ComWrErc1Sa16RetarderEnableBrakeAssistSwitch" VALUE 0x80028254 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrErc1Sa16RetarderEnableShiftAssistSwitch "SWTST_ku8ComWrErc1Sa16RetarderEnableShiftAssistSwitch" VALUE 0x80028253 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrErc1Sa16RetarderRequestingBrakeLight "SWTST_ku8ComWrErc1Sa16RetarderRequestingBrakeLight" VALUE 0x80028252 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrErc1Sa16RetarderRoadSpeedExceededStatus "SWTST_ku8ComWrErc1Sa16RetarderRoadSpeedExceededStatus" VALUE 0x80028251 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrErc1Sa16RetarderRoadSpeedLimitSwitch "SWTST_ku8ComWrErc1Sa16RetarderRoadSpeedLimitSwitch" VALUE 0x80028250 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrErc1Sa16RetarderTorqueMode "SWTST_ku8ComWrErc1Sa16RetarderTorqueMode" VALUE 0x8002824F DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrErc1Sa16SrcAddrssOfCntrllngDvcFrRtrdrCtr "SWTST_ku8ComWrErc1Sa16SrcAddrssOfCntrllngDvcFrRtrdrCtr" VALUE 0x8002824E DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEtc1Sa03EngMomentaryOverspeedEnable "SWTST_ku8ComWrEtc1Sa03EngMomentaryOverspeedEnable" VALUE 0x8002824D DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEtc1Sa03MomentaryEngMaxPowerEnable "SWTST_ku8ComWrEtc1Sa03MomentaryEngMaxPowerEnable" VALUE 0x8002824C DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEtc1Sa03ProgressiveShiftDisable "SWTST_ku8ComWrEtc1Sa03ProgressiveShiftDisable" VALUE 0x8002824B DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEtc1Sa03SrcAddrssOfCntrllngDvcFrTrnsCtrl "SWTST_ku8ComWrEtc1Sa03SrcAddrssOfCntrllngDvcFrTrnsCtrl" VALUE 0x8002824A DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEtc1Sa03TransDrivelineEngaged "SWTST_ku8ComWrEtc1Sa03TransDrivelineEngaged" VALUE 0x80028249 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEtc1Sa03TransShiftInProcess "SWTST_ku8ComWrEtc1Sa03TransShiftInProcess" VALUE 0x80028248 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEtc1Sa03TrnsTorqueConverterLockupEngaged "SWTST_ku8ComWrEtc1Sa03TrnsTorqueConverterLockupEngaged" VALUE 0x80028247 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEtc1Sa03TrnsTrqCnvrtrLckpTrnstnInProcess "SWTST_ku8ComWrEtc1Sa03TrnsTrqCnvrtrLckpTrnstnInProcess" VALUE 0x80028246 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEtc7Sa03ActiveShiftConsoleIndicator "SWTST_ku8ComWrEtc7Sa03ActiveShiftConsoleIndicator" VALUE 0x80028245 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEtc7Sa03TransAirSupplyPressIndicator "SWTST_ku8ComWrEtc7Sa03TransAirSupplyPressIndicator" VALUE 0x80028244 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEtc7Sa03TransAutoNeutralSt "SWTST_ku8ComWrEtc7Sa03TransAutoNeutralSt" VALUE 0x80028243 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEtc7Sa03TransEngCrankEnable "SWTST_ku8ComWrEtc7Sa03TransEngCrankEnable" VALUE 0x80028242 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEtc7Sa03TransMode10Indicator "SWTST_ku8ComWrEtc7Sa03TransMode10Indicator" VALUE 0x80028241 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEtc7Sa03TransMode1Indicator "SWTST_ku8ComWrEtc7Sa03TransMode1Indicator" VALUE 0x80028240 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEtc7Sa03TransMode2Indicator "SWTST_ku8ComWrEtc7Sa03TransMode2Indicator" VALUE 0x8002823F DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEtc7Sa03TransMode3Indicator "SWTST_ku8ComWrEtc7Sa03TransMode3Indicator" VALUE 0x8002823E DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEtc7Sa03TransMode4Indicator "SWTST_ku8ComWrEtc7Sa03TransMode4Indicator" VALUE 0x8002823D DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEtc7Sa03TransMode5Indicator "SWTST_ku8ComWrEtc7Sa03TransMode5Indicator" VALUE 0x8002823C DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEtc7Sa03TransMode6Indicator "SWTST_ku8ComWrEtc7Sa03TransMode6Indicator" VALUE 0x8002823B DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEtc7Sa03TransMode7Indicator "SWTST_ku8ComWrEtc7Sa03TransMode7Indicator" VALUE 0x8002823A DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEtc7Sa03TransMode8Indicator "SWTST_ku8ComWrEtc7Sa03TransMode8Indicator" VALUE 0x80028239 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEtc7Sa03TransMode9Indicator "SWTST_ku8ComWrEtc7Sa03TransMode9Indicator" VALUE 0x80028238 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEtc7Sa03TransReadyForBrakeRelease "SWTST_ku8ComWrEtc7Sa03TransReadyForBrakeRelease" VALUE 0x80028237 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEtc7Sa03TransServiceIndicator "SWTST_ku8ComWrEtc7Sa03TransServiceIndicator" VALUE 0x80028236 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEtc7Sa03TransShiftInhibitIndicator "SWTST_ku8ComWrEtc7Sa03TransShiftInhibitIndicator" VALUE 0x80028235 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEtc7Sa03TransWarningIndicator "SWTST_ku8ComWrEtc7Sa03TransWarningIndicator" VALUE 0x80028234 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEtc7Sa03TrnsCrrentRangeDisplayBlankState "SWTST_ku8ComWrEtc7Sa03TrnsCrrentRangeDisplayBlankState" VALUE 0x80028233 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEtc7Sa03TrnsRqstedRangeDisplayBlankState "SWTST_ku8ComWrEtc7Sa03TrnsRqstedRangeDisplayBlankState" VALUE 0x80028232 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEtc7Sa03TrnsRqstedRangeDisplayFlashState "SWTST_ku8ComWrEtc7Sa03TrnsRqstedRangeDisplayFlashState" VALUE 0x80028231 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrEtc7Sa03TrnsRverseGearShiftInhibitStatus "SWTST_ku8ComWrEtc7Sa03TrnsRverseGearShiftInhibitStatus" VALUE 0x80028230 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrJ2012Sa03J2012DTCOccurrenceCount "SWTST_ku8ComWrJ2012Sa03J2012DTCOccurrenceCount" VALUE 0x8002822F DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrJ2012Sa03J2012DTCStatus "SWTST_ku8ComWrJ2012Sa03J2012DTCStatus" VALUE 0x8002822E DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrJ2012Sa03NumberOfJ2012DTCs "SWTST_ku8ComWrJ2012Sa03NumberOfJ2012DTCs" VALUE 0x8002822D DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrPtodeSa03AtLeastOnePTOEngaged "SWTST_ku8ComWrPtodeSa03AtLeastOnePTOEngaged" VALUE 0x8002822C DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrPtodeSa03EnableSwitchPTOEngFlywheel "SWTST_ku8ComWrPtodeSa03EnableSwitchPTOEngFlywheel" VALUE 0x8002822B DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrPtodeSa03EnableSwitchTransInputShaftPTO1 "SWTST_ku8ComWrPtodeSa03EnableSwitchTransInputShaftPTO1" VALUE 0x8002822A DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrPtodeSa03EnableSwitchTransInputShaftPTO2 "SWTST_ku8ComWrPtodeSa03EnableSwitchTransInputShaftPTO2" VALUE 0x80028229 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrPtodeSa03EnableSwitchTransOutputShaftPTO "SWTST_ku8ComWrPtodeSa03EnableSwitchTransOutputShaftPTO" VALUE 0x80028228 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrPtodeSa03EnblSwtchTrnsfrCseOutputShaftPTO "SWTST_ku8ComWrPtodeSa03EnblSwtchTrnsfrCseOutputShaftPTO" VALUE 0x80028225 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrPtodeSa03EnbleSwitchPTOEngAccessoryDrive1 "SWTST_ku8ComWrPtodeSa03EnbleSwitchPTOEngAccessoryDrive1" VALUE 0x80028227 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrPtodeSa03EnbleSwitchPTOEngAccessoryDrive2 "SWTST_ku8ComWrPtodeSa03EnbleSwitchPTOEngAccessoryDrive2" VALUE 0x80028226 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrPtodeSa03EngagementConsentPTOEngFlywheel "SWTST_ku8ComWrPtodeSa03EngagementConsentPTOEngFlywheel" VALUE 0x80028224 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrPtodeSa03EngagementStatusPTOEngFlywheel "SWTST_ku8ComWrPtodeSa03EngagementStatusPTOEngFlywheel" VALUE 0x80028223 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrPtodeSa03EnggmntCnsentTransInputShaftPTO1 "SWTST_ku8ComWrPtodeSa03EnggmntCnsentTransInputShaftPTO1" VALUE 0x80028222 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrPtodeSa03EnggmntCnsentTransInputShaftPTO2 "SWTST_ku8ComWrPtodeSa03EnggmntCnsentTransInputShaftPTO2" VALUE 0x80028221 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrPtodeSa03EnggmntCnsentTransOutputShaftPTO "SWTST_ku8ComWrPtodeSa03EnggmntCnsentTransOutputShaftPTO" VALUE 0x80028220 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrPtodeSa03EnggmntCnsntPTOEngAccssoryDrive1 "SWTST_ku8ComWrPtodeSa03EnggmntCnsntPTOEngAccssoryDrive1" VALUE 0x8002821F DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrPtodeSa03EnggmntCnsntPTOEngAccssoryDrive2 "SWTST_ku8ComWrPtodeSa03EnggmntCnsntPTOEngAccssoryDrive2" VALUE 0x8002821E DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrPtodeSa03EnggmntCnsntTrnsfrCsOtptShaftPTO "SWTST_ku8ComWrPtodeSa03EnggmntCnsntTrnsfrCsOtptShaftPTO" VALUE 0x8002821D DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrPtodeSa03EnggmntStatusTransInputShaftPTO1 "SWTST_ku8ComWrPtodeSa03EnggmntStatusTransInputShaftPTO1" VALUE 0x8002821C DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrPtodeSa03EnggmntStatusTransInputShaftPTO2 "SWTST_ku8ComWrPtodeSa03EnggmntStatusTransInputShaftPTO2" VALUE 0x8002821B DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrPtodeSa03EnggmntStatusTransOutputShaftPTO "SWTST_ku8ComWrPtodeSa03EnggmntStatusTransOutputShaftPTO" VALUE 0x8002821A DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrPtodeSa03EnggmntSttsPTOEngAccessoryDrive1 "SWTST_ku8ComWrPtodeSa03EnggmntSttsPTOEngAccessoryDrive1" VALUE 0x80028219 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrPtodeSa03EnggmntSttsPTOEngAccessoryDrive2 "SWTST_ku8ComWrPtodeSa03EnggmntSttsPTOEngAccessoryDrive2" VALUE 0x80028218 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrPtodeSa03EnggmntSttsTrnsfrCsOtputShaftPTO "SWTST_ku8ComWrPtodeSa03EnggmntSttsTrnsfrCsOtputShaftPTO" VALUE 0x80028217 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrRcSa16RetarderCtrlMethod "SWTST_ku8ComWrRcSa16RetarderCtrlMethod" VALUE 0x80028216 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrRcSa16RetarderLocation "SWTST_ku8ComWrRcSa16RetarderLocation" VALUE 0x80028215 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrRcSa16RetarderType "SWTST_ku8ComWrRcSa16RetarderType" VALUE 0x80028214 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrRfSa16DrvlineRetarderOverheatIndicator "SWTST_ku8ComWrRfSa16DrvlineRetarderOverheatIndicator" VALUE 0x80028213 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrSOFTSa254NmbrOfSftwreIdentificationFields "SWTST_ku8ComWrSOFTSa254NmbrOfSftwreIdentificationFields" VALUE 0x8002814A DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrSOFTSa254SoftwareIdentification "SWTST_ku8ComWrSOFTSa254SoftwareIdentification" VALUE 0x80028149 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrSoft "SWTST_ku8ComWrSoft" CURVE 0x8002814B DATA_RECORD_UBYTE 255 I_5 0 255
 /begin AXIS_DESCR FIX_AXIS NO_INPUT_QUANTITY Id_0x00 200 0 199 MAX_GRAD 100.0 FIX_AXIS_PAR_DIST 0 1 200 /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTrf1Sa03TransOilLevel1CountdownTimer "SWTST_ku8ComWrTrf1Sa03TransOilLevel1CountdownTimer" VALUE 0x80028148 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTrf1Sa03TransOilLevel1MeasurementStatus "SWTST_ku8ComWrTrf1Sa03TransOilLevel1MeasurementStatus" VALUE 0x80028147 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTrf2Sa03TransOilFilterRestrictionSwitch "SWTST_ku8ComWrTrf2Sa03TransOilFilterRestrictionSwitch" VALUE 0x80028146 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTrf2Sa03TransOilLevel2CountdownTimer "SWTST_ku8ComWrTrf2Sa03TransOilLevel2CountdownTimer" VALUE 0x80028145 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTrf2Sa03TransOilLevel2MeasurementStatus "SWTST_ku8ComWrTrf2Sa03TransOilLevel2MeasurementStatus" VALUE 0x80028144 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTrf2Sa03TransOilLevelSwitch "SWTST_ku8ComWrTrf2Sa03TransOilLevelSwitch" VALUE 0x80028143 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTrf2Sa03TransOverheatIndicator "SWTST_ku8ComWrTrf2Sa03TransOverheatIndicator" VALUE 0x80028142 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTsc1Sa03EngOverrideCtrlMode "SWTST_ku8ComWrTsc1Sa03EngOverrideCtrlMode" VALUE 0x80028141 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTsc1Sa03EngRequestedSpeedCtrlConditions "SWTST_ku8ComWrTsc1Sa03EngRequestedSpeedCtrlConditions" VALUE 0x80028140 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTsc1Sa03MessageChecksum "SWTST_ku8ComWrTsc1Sa03MessageChecksum" VALUE 0x8002813F DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTsc1Sa03MessageCounter "SWTST_ku8ComWrTsc1Sa03MessageCounter" VALUE 0x8002813E DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTsc1Sa03OverrideCtrlModePriority "SWTST_ku8ComWrTsc1Sa03OverrideCtrlModePriority" VALUE 0x8002813D DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTsc1Sa03TSC1CtrlPurpose "SWTST_ku8ComWrTsc1Sa03TSC1CtrlPurpose" VALUE 0x8002813C DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTsc1Sa03TSC1TransRate "SWTST_ku8ComWrTsc1Sa03TSC1TransRate" VALUE 0x8002813B DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBHVAttachSa208TxDBBrkPumpSta "SWTST_ku8ComWrTxDBHVAttachSa208TxDBBrkPumpSta" VALUE 0x80028139 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBHVAttachSa208TxDBDCDCSta "SWTST_ku8ComWrTxDBHVAttachSa208TxDBDCDCSta" VALUE 0x80028138 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBHVAttachSa208TxDBSteerPumpSta "SWTST_ku8ComWrTxDBHVAttachSa208TxDBSteerPumpSta" VALUE 0x80028137 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBHVAttachSa208TxDBUrgentSwitch "SWTST_ku8ComWrTxDBHVAttachSa208TxDBUrgentSwitch" VALUE 0x80028136 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBHVAttachSa208cntTCU "SWTST_ku8ComWrTxDBHVAttachSa208cntTCU" VALUE 0x8002813A DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBHVBoardSa208TxDBAirCondErr "SWTST_ku8ComWrTxDBHVBoardSa208TxDBAirCondErr" VALUE 0x80028135 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBHVBoardSa208TxDBDefrostErr "SWTST_ku8ComWrTxDBHVBoardSa208TxDBDefrostErr" VALUE 0x80028134 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBHVBoardSa208TxDBEleAttErr "SWTST_ku8ComWrTxDBHVBoardSa208TxDBEleAttErr" VALUE 0x80028133 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBHVBoardSa208TxDBEleAttPreChargeErr "SWTST_ku8ComWrTxDBHVBoardSa208TxDBEleAttPreChargeErr" VALUE 0x80028132 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBHVBoardSa208TxDBEleAttPreChargeSta "SWTST_ku8ComWrTxDBHVBoardSa208TxDBEleAttPreChargeSta" VALUE 0x80028131 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBHVBoardSa208TxDBEleAttSta "SWTST_ku8ComWrTxDBHVBoardSa208TxDBEleAttSta" VALUE 0x80028130 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBHVBoardSa208TxDBMainMotErr "SWTST_ku8ComWrTxDBHVBoardSa208TxDBMainMotErr" VALUE 0x8002812F DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBHVBoardSa208TxDBMainMotSta "SWTST_ku8ComWrTxDBHVBoardSa208TxDBMainMotSta" VALUE 0x8002812E DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBHVBoardSa208TxDBMainPreChargeErr "SWTST_ku8ComWrTxDBHVBoardSa208TxDBMainPreChargeErr" VALUE 0x8002812D DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBHVBoardSa208TxDBMainPreChargeSta "SWTST_ku8ComWrTxDBHVBoardSa208TxDBMainPreChargeSta" VALUE 0x8002812C DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBHVBoardSa208TxDBPtcErr "SWTST_ku8ComWrTxDBHVBoardSa208TxDBPtcErr" VALUE 0x8002812B DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBStaMCU1Sa240TxDBBraCtrlSta "SWTST_ku8ComWrTxDBStaMCU1Sa240TxDBBraCtrlSta" VALUE 0x8002812A DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBStaMCU1Sa240TxDBCANErrWarn "SWTST_ku8ComWrTxDBStaMCU1Sa240TxDBCANErrWarn" VALUE 0x80028129 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBStaMCU1Sa240TxDBDriCtrlSta "SWTST_ku8ComWrTxDBStaMCU1Sa240TxDBDriCtrlSta" VALUE 0x80028128 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBStaMCU1Sa240TxDBErrCode "SWTST_ku8ComWrTxDBStaMCU1Sa240TxDBErrCode" VALUE 0x80028127 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBStaMCU1Sa240TxDBErrSta "SWTST_ku8ComWrTxDBStaMCU1Sa240TxDBErrSta" VALUE 0x80028126 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBStaMCU1Sa240TxDBMCUTempWarn "SWTST_ku8ComWrTxDBStaMCU1Sa240TxDBMCUTempWarn" VALUE 0x80028125 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBStaMCU1Sa240TxDBMotTempWarn "SWTST_ku8ComWrTxDBStaMCU1Sa240TxDBMotTempWarn" VALUE 0x80028124 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBStaMCU1Sa240TxDBOverCurrWarn "SWTST_ku8ComWrTxDBStaMCU1Sa240TxDBOverCurrWarn" VALUE 0x80028123 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBStaMCU1Sa240TxDBOverVoltWarn "SWTST_ku8ComWrTxDBStaMCU1Sa240TxDBOverVoltWarn" VALUE 0x80028122 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBStaMCU1Sa240TxDBRevCtrlSta "SWTST_ku8ComWrTxDBStaMCU1Sa240TxDBRevCtrlSta" VALUE 0x80028121 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBStaMCU1Sa240TxDBSelfCheckCtrlSta "SWTST_ku8ComWrTxDBStaMCU1Sa240TxDBSelfCheckCtrlSta" VALUE 0x80028120 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBStaMCU1Sa240TxDBUnderVoltWarn "SWTST_ku8ComWrTxDBStaMCU1Sa240TxDBUnderVoltWarn" VALUE 0x8002811F DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBStaVCU1Sa208TxDBCanErr "SWTST_ku8ComWrTxDBStaVCU1Sa208TxDBCanErr" VALUE 0x8002811E DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBStaVCU1Sa208TxDBGearCurrNum "SWTST_ku8ComWrTxDBStaVCU1Sa208TxDBGearCurrNum" VALUE 0x8002811D DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBStaVCU1Sa208TxDBInterLock "SWTST_ku8ComWrTxDBStaVCU1Sa208TxDBInterLock" VALUE 0x8002811C DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBStaVCU1Sa208TxDBStaBmsRelay "SWTST_ku8ComWrTxDBStaVCU1Sa208TxDBStaBmsRelay" VALUE 0x8002811B DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBStaVCU1Sa208TxDBStaVeh "SWTST_ku8ComWrTxDBStaVCU1Sa208TxDBStaVeh" VALUE 0x8002811A DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBStaVCU1Sa208TxDBTransErr "SWTST_ku8ComWrTxDBStaVCU1Sa208TxDBTransErr" VALUE 0x80028119 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBStaVCU1Sa208TxDBVcuCnt "SWTST_ku8ComWrTxDBStaVCU1Sa208TxDBVcuCnt" VALUE 0x80028118 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBStaVCU1Sa208TxDBVcuErr "SWTST_ku8ComWrTxDBStaVCU1Sa208TxDBVcuErr" VALUE 0x80028117 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBStaVCU1Sa208TxDBVcuErrCode "SWTST_ku8ComWrTxDBStaVCU1Sa208TxDBVcuErrCode" VALUE 0x80028116 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxDBStaVCU1Sa208TxDBVcuSelfCheck "SWTST_ku8ComWrTxDBStaVCU1Sa208TxDBVcuSelfCheck" VALUE 0x80028115 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxMCUCmdSa208TxMCUFaultReset "SWTST_ku8ComWrTxMCUCmdSa208TxMCUFaultReset" VALUE 0x80028114 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxMCUCmdSa208TxMCULiveCounter "SWTST_ku8ComWrTxMCUCmdSa208TxMCULiveCounter" VALUE 0x80028113 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxMCUCmdSa208TxMCUMotCtrlModeCmd "SWTST_ku8ComWrTxMCUCmdSa208TxMCUMotCtrlModeCmd" VALUE 0x80028112 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxMCUCmdSa208TxMCUMotStaCmd "SWTST_ku8ComWrTxMCUCmdSa208TxMCUMotStaCmd" VALUE 0x80028111 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxMultCtrlSa208TxMultCtrlBrkPumpCmd "SWTST_ku8ComWrTxMultCtrlSa208TxMultCtrlBrkPumpCmd" VALUE 0x80028110 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxMultCtrlSa208TxMultCtrlMotHVCmd "SWTST_ku8ComWrTxMultCtrlSa208TxMultCtrlMotHVCmd" VALUE 0x8002810F DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8ComWrTxMultCtrlSa208TxMultCtrlSteerPumpCmd "SWTST_ku8ComWrTxMultCtrlSa208TxMultCtrlSteerPumpCmd" VALUE 0x8002810E DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8DiagcTstNrC "Test number" VALUE 0x8002810D DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8DioTstNrC "Test number" VALUE 0x8002810C DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8FimTstNrC "Test number" VALUE 0x8002810B DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8SftySubTstNrC "Test number" VALUE 0x8002810A DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8SftyTstNrC "Test number" VALUE 0x80028109 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8Tle62X0TstNrC "Test number" VALUE 0x80028108 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8Tle8242TstNrC "Test number" VALUE 0x80028107 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8TrimTstNrC "Test number" VALUE 0x80028106 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_ku8WdgTstNrC "Test number" VALUE 0x80028105 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_u8TLE8242_LINEAR_VALVE_1_1_PwmOffs "SWTST_u8TLE8242_LINEAR_VALVE_1_1_PwmOffs" VALUE 0x80028104 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_u8TLE8242_LINEAR_VALVE_1_2_PwmOffs "SWTST_u8TLE8242_LINEAR_VALVE_1_2_PwmOffs" VALUE 0x80028103 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_u8TLE8242_LINEAR_VALVE_2_3_PwmOffs "SWTST_u8TLE8242_LINEAR_VALVE_2_3_PwmOffs" VALUE 0x80028102 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_u8TLE8242_LINEAR_VALVE_2_4_PwmOffs "SWTST_u8TLE8242_LINEAR_VALVE_2_4_PwmOffs" VALUE 0x80028101 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_u8TLE8242_LINEAR_VALVE_2_5_PwmOffs "SWTST_u8TLE8242_LINEAR_VALVE_2_5_PwmOffs" VALUE 0x80028100 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_u8TLE8242_LINEAR_VALVE_3_6_PwmOffs "SWTST_u8TLE8242_LINEAR_VALVE_3_6_PwmOffs" VALUE 0x800280FF DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_u8TLE8242_LINEAR_VALVE_3_7_PwmOffs "SWTST_u8TLE8242_LINEAR_VALVE_3_7_PwmOffs" VALUE 0x800280FE DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_u8TLE8242_LINEAR_VALVE_3_8_PwmOffs "SWTST_u8TLE8242_LINEAR_VALVE_3_8_PwmOffs" VALUE 0x800280FD DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_u8TLE8242_LINEAR_VALVE_4_10_PwmOffs "SWTST_u8TLE8242_LINEAR_VALVE_4_10_PwmOffs" VALUE 0x800280FC DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_u8TLE8242_LINEAR_VALVE_4_9_PwmOffs "SWTST_u8TLE8242_LINEAR_VALVE_4_9_PwmOffs" VALUE 0x800280FB DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_u8TLE8242_PWM_VALVE_1_1_PwmOffs "SWTST_u8TLE8242_PWM_VALVE_1_1_PwmOffs" VALUE 0x800280FA DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_u8TLE8242_PWM_VALVE_1_2_PwmOffs "SWTST_u8TLE8242_PWM_VALVE_1_2_PwmOffs" VALUE 0x800280F9 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_u8TLE8242_PWM_VALVE_1_3_PwmOffs "SWTST_u8TLE8242_PWM_VALVE_1_3_PwmOffs" VALUE 0x800280F8 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_u8TLE8242_PWM_VALVE_4_4_PwmOffs "SWTST_u8TLE8242_PWM_VALVE_4_4_PwmOffs" VALUE 0x800280F7 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_u8TLE8242_PWM_VALVE_4_5_PwmOffs "SWTST_u8TLE8242_PWM_VALVE_4_5_PwmOffs" VALUE 0x800280F6 DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC TEMP_ks16TempDeltaMaxThd "Delta min between temperature of PCB and temperature of microcontroller" VALUE 0x800286EE DATA_RECORD_SWORD 4095.9375 F_0v0625_p0_34 -2048 2047.9375 /end CHARACTERISTIC
/begin CHARACTERISTIC TEMP_ks16TempDeltaMinThd "Delta max between temperature of PCB and temperature of microcontroller" VALUE 0x800286EC DATA_RECORD_SWORD 4095.9375 F_0v0625_p0_34 -2048 2047.9375 /end CHARACTERISTIC
/begin CHARACTERISTIC TEMP_ks16TempDieMaxThd "Max temperature of PCB" VALUE 0x800286EA DATA_RECORD_SWORD 4095.9375 F_0v0625_p0_34 -2048 2047.9375 /end CHARACTERISTIC
/begin CHARACTERISTIC TEMP_ks16TempDieMinThd "Min temperature of PCB" VALUE 0x800286E8 DATA_RECORD_SWORD 4095.9375 F_0v0625_p0_34 -2048 2047.9375 /end CHARACTERISTIC
/begin CHARACTERISTIC TEMP_ks16TempPcbMaxThd "Max temperature of microcontroller" VALUE 0x800286E6 DATA_RECORD_SWORD 4095.9375 F_0v0625_p0_34 -2048 2047.9375 /end CHARACTERISTIC
/begin CHARACTERISTIC TEMP_ks16TempPcbMinThd "Min temperature of microcontroller" VALUE 0x800286E4 DATA_RECORD_SWORD 4095.9375 F_0v0625_p0_34 -2048 2047.9375 /end CHARACTERISTIC
/begin CHARACTERISTIC TLE8242_kaf32DutyCycle "TLE8242_kaf32DutyCycle" CURVE 0x8002887C DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p0_6 -3.402823466E+038 3.402823466E+038
 /begin AXIS_DESCR FIX_AXIS NO_INPUT_QUANTITY Id_0x00 15 0 14 MAX_GRAD 100.0 FIX_AXIS_PAR_DIST 0 1 15 /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC TLE8242_kau16KI "TLE8242_kau16KI" CURVE 0x80028822 DATA_RECORD_UWORD 65535 F_1_p0_6 0 65535
 /begin AXIS_DESCR FIX_AXIS NO_INPUT_QUANTITY Id_0x00 15 0 14 MAX_GRAD 100.0 FIX_AXIS_PAR_DIST 0 1 15 /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC TLE8242_kau16KP "TLE8242_kau16KP" CURVE 0x80028804 DATA_RECORD_UWORD 65535 F_1_p0_6 0 65535
 /begin AXIS_DESCR FIX_AXIS NO_INPUT_QUANTITY Id_0x00 15 0 14 MAX_GRAD 100.0 FIX_AXIS_PAR_DIST 0 1 15 /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC TLE8242_kau8OpenLoop "TLE8242_kau8OpenLoop" CURVE 0x800287F4 DATA_RECORD_UBYTE 255 F_1_p0_6 0 255
 /begin AXIS_DESCR FIX_AXIS NO_INPUT_QUANTITY Id_0x00 15 0 14 MAX_GRAD 100.0 FIX_AXIS_PAR_DIST 0 1 15 /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC TLE8242_kau8ReadCrntRetMax "TLE8242_kau8ReadCrntRetMax" VALUE 0x800287E9 DATA_RECORD_UBYTE 0 F_1_p0_6 0 0 /end CHARACTERISTIC
/begin CHARACTERISTIC TLE8242_kf32ChopperFrqMaxThd "TLE8242_kf32ChopperFrqMaxThd" VALUE 0x800288BC DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p0_6 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC TLE8242_kf32ChopperFrqMinThd "TLE8242_kf32ChopperFrqMinThd" VALUE 0x800288B8 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p0_6 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC TLE8242_kf32MinChgForCrnt "TLE8242_kf32MinChgForCrnt" VALUE 0x800286F4 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p0_6 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC TLE8242_kf32MinChgForFrqPrm "TLE8242_kf32MinChgForFrqPrm" VALUE 0x800286F0 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p0_6 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC TLE8242_kf32OverUnderLoadThd "TLE8242_kf32OverUnderLoadThd" VALUE 0x800287EC DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p0_6 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC TLE8242_kf32R_Shunt "TLE8242_kf32R_Shunt" VALUE 0x800287F0 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p0_6 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC TLE8242_kf32TrimGrdtOfFuncGt "TLE8242_kf32TrimGrdtOfFuncGt" CURVE 0x800287AC DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p0_6 -3.402823466E+038 3.402823466E+038
 /begin AXIS_DESCR FIX_AXIS NO_INPUT_QUANTITY Id_0x00 15 0 14 MAX_GRAD 100.0 FIX_AXIS_PAR_DIST 0 1 15 /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC TLE8242_kf32TrimGrdtOfFuncOt "TLE8242_kf32TrimGrdtOfFuncOt" CURVE 0x80028770 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p0_6 -3.402823466E+038 3.402823466E+038
 /begin AXIS_DESCR FIX_AXIS NO_INPUT_QUANTITY Id_0x00 15 0 14 MAX_GRAD 100.0 FIX_AXIS_PAR_DIST 0 1 15 /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC TLE8242_kf32TrimOffsOfFuncGt "TLE8242_kf32TrimOffsOfFuncGt" CURVE 0x800286F8 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p0_6 -3.402823466E+038 3.402823466E+038
 /begin AXIS_DESCR FIX_AXIS NO_INPUT_QUANTITY Id_0x00 15 0 14 MAX_GRAD 100.0 FIX_AXIS_PAR_DIST 0 1 15 /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC TLE8242_kf32TrimOffsOfFuncOt "TLE8242_kf32TrimOffsOfFuncOt" CURVE 0x80028734 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p0_6 -3.402823466E+038 3.402823466E+038
 /begin AXIS_DESCR FIX_AXIS NO_INPUT_QUANTITY Id_0x00 15 0 14 MAX_GRAD 100.0 FIX_AXIS_PAR_DIST 0 1 15 /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC TLE8242_ku8AutoZeroEna "TLE8242_ku8AutoZeroEna" VALUE 0x800287E8 DATA_RECORD_UBYTE 255 F_1_p0_6 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC TST_PWM_bPWM_ENA_SPEEDOMETER "TST_PWM_bPWM_ENA_SPEEDOMETER" VALUE 0x800284E4 DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC TST_PWM_s16PWM_DUTY_SPEEDOMETER "TST_PWM_s16PWM_DUTY_SPEEDOMETER" VALUE 0x800280F4 DATA_RECORD_SWORD 399.9938965 F_0v0061035156_p0_26 -200 199.9938965 /end CHARACTERISTIC
/begin CHARACTERISTIC TST_PWM_u32PWM_FRQ_SPEEDOMETER "TST_PWM_u32PWM_FRQ_SPEEDOMETER" VALUE 0x800284D0 DATA_RECORD_ULONG 4294967295 F_1_p0_37 0 4294967295 /end CHARACTERISTIC
/begin MEASUREMENT SPDSNSRSIRSETN_enuDir "SPDSNSRSIRSETN_enuDir" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600009AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TEMP_s16PhysTempDie "TEMP_s16PhysTempDie" SWORD F_0v0625_p0_34 1 2 -2048 2047.9375 ECU_ADDRESS 0x600009B2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TEMP_s16PhysTempPcb "TEMP_s16PhysTempPcb" SWORD F_0v0625_p0_34 1 2 -2048 2047.9375 ECU_ADDRESS 0x600009B0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abDitherAmplCompRes "dither ampl" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 MATRIX_DIM 15 1 1 ECU_ADDRESS 0x60008250 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abDitherAmplCompRes[0] "TLE8242_abDitherAmplCompRes[0]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60008250 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abDitherAmplCompRes[10] "TLE8242_abDitherAmplCompRes[10]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x6000825A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abDitherAmplCompRes[11] "TLE8242_abDitherAmplCompRes[11]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x6000825B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abDitherAmplCompRes[12] "TLE8242_abDitherAmplCompRes[12]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x6000825C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abDitherAmplCompRes[13] "TLE8242_abDitherAmplCompRes[13]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x6000825D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abDitherAmplCompRes[14] "TLE8242_abDitherAmplCompRes[14]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x6000825E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abDitherAmplCompRes[1] "TLE8242_abDitherAmplCompRes[1]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60008251 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abDitherAmplCompRes[2] "TLE8242_abDitherAmplCompRes[2]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60008252 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abDitherAmplCompRes[3] "TLE8242_abDitherAmplCompRes[3]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60008253 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abDitherAmplCompRes[4] "TLE8242_abDitherAmplCompRes[4]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60008254 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abDitherAmplCompRes[5] "TLE8242_abDitherAmplCompRes[5]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60008255 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abDitherAmplCompRes[6] "TLE8242_abDitherAmplCompRes[6]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60008256 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abDitherAmplCompRes[7] "TLE8242_abDitherAmplCompRes[7]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60008257 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abDitherAmplCompRes[8] "TLE8242_abDitherAmplCompRes[8]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60008258 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abDitherAmplCompRes[9] "TLE8242_abDitherAmplCompRes[9]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60008259 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abDitherFrqCompRes "dither frequency" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 MATRIX_DIM 15 1 1 ECU_ADDRESS 0x6000825F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abDitherFrqCompRes[0] "TLE8242_abDitherFrqCompRes[0]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x6000825F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abDitherFrqCompRes[10] "TLE8242_abDitherFrqCompRes[10]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60008269 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abDitherFrqCompRes[11] "TLE8242_abDitherFrqCompRes[11]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x6000826A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abDitherFrqCompRes[12] "TLE8242_abDitherFrqCompRes[12]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x6000826B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abDitherFrqCompRes[13] "TLE8242_abDitherFrqCompRes[13]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x6000826C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abDitherFrqCompRes[14] "TLE8242_abDitherFrqCompRes[14]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x6000826D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abDitherFrqCompRes[1] "TLE8242_abDitherFrqCompRes[1]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60008260 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abDitherFrqCompRes[2] "TLE8242_abDitherFrqCompRes[2]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60008261 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abDitherFrqCompRes[3] "TLE8242_abDitherFrqCompRes[3]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60008262 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abDitherFrqCompRes[4] "TLE8242_abDitherFrqCompRes[4]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60008263 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abDitherFrqCompRes[5] "TLE8242_abDitherFrqCompRes[5]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60008264 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abDitherFrqCompRes[6] "TLE8242_abDitherFrqCompRes[6]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60008265 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abDitherFrqCompRes[7] "TLE8242_abDitherFrqCompRes[7]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60008266 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abDitherFrqCompRes[8] "TLE8242_abDitherFrqCompRes[8]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60008267 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abDitherFrqCompRes[9] "TLE8242_abDitherFrqCompRes[9]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60008268 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abTarCrntCompRes "Target current" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 MATRIX_DIM 15 1 1 ECU_ADDRESS 0x6000826E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abTarCrntCompRes[0] "TLE8242_abTarCrntCompRes[0]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x6000826E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abTarCrntCompRes[10] "TLE8242_abTarCrntCompRes[10]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60008278 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abTarCrntCompRes[11] "TLE8242_abTarCrntCompRes[11]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60008279 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abTarCrntCompRes[12] "TLE8242_abTarCrntCompRes[12]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x6000827A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abTarCrntCompRes[13] "TLE8242_abTarCrntCompRes[13]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x6000827B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abTarCrntCompRes[14] "TLE8242_abTarCrntCompRes[14]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x6000827C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abTarCrntCompRes[1] "TLE8242_abTarCrntCompRes[1]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x6000826F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abTarCrntCompRes[2] "TLE8242_abTarCrntCompRes[2]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60008270 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abTarCrntCompRes[3] "TLE8242_abTarCrntCompRes[3]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60008271 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abTarCrntCompRes[4] "TLE8242_abTarCrntCompRes[4]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60008272 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abTarCrntCompRes[5] "TLE8242_abTarCrntCompRes[5]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60008273 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abTarCrntCompRes[6] "TLE8242_abTarCrntCompRes[6]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60008274 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abTarCrntCompRes[7] "TLE8242_abTarCrntCompRes[7]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60008275 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abTarCrntCompRes[8] "TLE8242_abTarCrntCompRes[8]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60008276 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_abTarCrntCompRes[9] "TLE8242_abTarCrntCompRes[9]" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60008277 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32AvgCrntMa "average current" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 MATRIX_DIM 15 1 1 ECU_ADDRESS 0x600084F4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32AvgCrntMa[0] "TLE8242_af32AvgCrntMa[0]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600084F4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32AvgCrntMa[10] "TLE8242_af32AvgCrntMa[10]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6000851C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32AvgCrntMa[11] "TLE8242_af32AvgCrntMa[11]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008520 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32AvgCrntMa[12] "TLE8242_af32AvgCrntMa[12]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008524 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32AvgCrntMa[13] "TLE8242_af32AvgCrntMa[13]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008528 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32AvgCrntMa[14] "TLE8242_af32AvgCrntMa[14]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6000852C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32AvgCrntMa[1] "TLE8242_af32AvgCrntMa[1]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600084F8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32AvgCrntMa[2] "TLE8242_af32AvgCrntMa[2]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600084FC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32AvgCrntMa[3] "TLE8242_af32AvgCrntMa[3]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008500 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32AvgCrntMa[4] "TLE8242_af32AvgCrntMa[4]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008504 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32AvgCrntMa[5] "TLE8242_af32AvgCrntMa[5]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008508 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32AvgCrntMa[6] "TLE8242_af32AvgCrntMa[6]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6000850C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32AvgCrntMa[7] "TLE8242_af32AvgCrntMa[7]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008510 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32AvgCrntMa[8] "TLE8242_af32AvgCrntMa[8]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008514 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32AvgCrntMa[9] "TLE8242_af32AvgCrntMa[9]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008518 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DitherAmplMa "dither ampl" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 MATRIX_DIM 15 1 1 ECU_ADDRESS 0x600084B8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DitherAmplMa[0] "TLE8242_af32DitherAmplMa[0]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600084B8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DitherAmplMa[10] "TLE8242_af32DitherAmplMa[10]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600084E0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DitherAmplMa[11] "TLE8242_af32DitherAmplMa[11]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600084E4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DitherAmplMa[12] "TLE8242_af32DitherAmplMa[12]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600084E8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DitherAmplMa[13] "TLE8242_af32DitherAmplMa[13]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600084EC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DitherAmplMa[14] "TLE8242_af32DitherAmplMa[14]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600084F0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DitherAmplMa[1] "TLE8242_af32DitherAmplMa[1]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600084BC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DitherAmplMa[2] "TLE8242_af32DitherAmplMa[2]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600084C0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DitherAmplMa[3] "TLE8242_af32DitherAmplMa[3]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600084C4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DitherAmplMa[4] "TLE8242_af32DitherAmplMa[4]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600084C8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DitherAmplMa[5] "TLE8242_af32DitherAmplMa[5]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600084CC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DitherAmplMa[6] "TLE8242_af32DitherAmplMa[6]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600084D0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DitherAmplMa[7] "TLE8242_af32DitherAmplMa[7]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600084D4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DitherAmplMa[8] "TLE8242_af32DitherAmplMa[8]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600084D8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DitherAmplMa[9] "TLE8242_af32DitherAmplMa[9]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600084DC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DitherFrq "dither frequency" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 MATRIX_DIM 15 1 1 ECU_ADDRESS 0x6000847C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DitherFrq[0] "TLE8242_af32DitherFrq[0]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6000847C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DitherFrq[10] "TLE8242_af32DitherFrq[10]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600084A4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DitherFrq[11] "TLE8242_af32DitherFrq[11]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600084A8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DitherFrq[12] "TLE8242_af32DitherFrq[12]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600084AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DitherFrq[13] "TLE8242_af32DitherFrq[13]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600084B0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DitherFrq[14] "TLE8242_af32DitherFrq[14]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600084B4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DitherFrq[1] "TLE8242_af32DitherFrq[1]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008480 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DitherFrq[2] "TLE8242_af32DitherFrq[2]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008484 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DitherFrq[3] "TLE8242_af32DitherFrq[3]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008488 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DitherFrq[4] "TLE8242_af32DitherFrq[4]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6000848C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DitherFrq[5] "TLE8242_af32DitherFrq[5]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008490 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DitherFrq[6] "TLE8242_af32DitherFrq[6]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008494 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DitherFrq[7] "TLE8242_af32DitherFrq[7]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008498 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DitherFrq[8] "TLE8242_af32DitherFrq[8]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6000849C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DitherFrq[9] "TLE8242_af32DitherFrq[9]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600084A0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DutyCycle "duty cycle" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 MATRIX_DIM 15 1 1 ECU_ADDRESS 0x60008440 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DutyCycle[0] "TLE8242_af32DutyCycle[0]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008440 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DutyCycle[10] "TLE8242_af32DutyCycle[10]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008468 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DutyCycle[11] "TLE8242_af32DutyCycle[11]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6000846C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DutyCycle[12] "TLE8242_af32DutyCycle[12]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008470 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DutyCycle[13] "TLE8242_af32DutyCycle[13]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008474 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DutyCycle[14] "TLE8242_af32DutyCycle[14]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008478 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DutyCycle[1] "TLE8242_af32DutyCycle[1]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008444 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DutyCycle[2] "TLE8242_af32DutyCycle[2]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008448 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DutyCycle[3] "TLE8242_af32DutyCycle[3]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6000844C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DutyCycle[4] "TLE8242_af32DutyCycle[4]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008450 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DutyCycle[5] "TLE8242_af32DutyCycle[5]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008454 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DutyCycle[6] "TLE8242_af32DutyCycle[6]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008458 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DutyCycle[7] "TLE8242_af32DutyCycle[7]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6000845C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DutyCycle[8] "TLE8242_af32DutyCycle[8]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008460 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32DutyCycle[9] "TLE8242_af32DutyCycle[9]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008464 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32MaxCnrtMa "mAximum current" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 MATRIX_DIM 15 1 1 ECU_ADDRESS 0x60008404 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32MaxCnrtMa[0] "TLE8242_af32MaxCnrtMa[0]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008404 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32MaxCnrtMa[10] "TLE8242_af32MaxCnrtMa[10]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6000842C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32MaxCnrtMa[11] "TLE8242_af32MaxCnrtMa[11]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008430 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32MaxCnrtMa[12] "TLE8242_af32MaxCnrtMa[12]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008434 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32MaxCnrtMa[13] "TLE8242_af32MaxCnrtMa[13]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008438 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32MaxCnrtMa[14] "TLE8242_af32MaxCnrtMa[14]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6000843C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32MaxCnrtMa[1] "TLE8242_af32MaxCnrtMa[1]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008408 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32MaxCnrtMa[2] "TLE8242_af32MaxCnrtMa[2]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6000840C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32MaxCnrtMa[3] "TLE8242_af32MaxCnrtMa[3]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008410 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32MaxCnrtMa[4] "TLE8242_af32MaxCnrtMa[4]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008414 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32MaxCnrtMa[5] "TLE8242_af32MaxCnrtMa[5]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008418 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32MaxCnrtMa[6] "TLE8242_af32MaxCnrtMa[6]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6000841C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32MaxCnrtMa[7] "TLE8242_af32MaxCnrtMa[7]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008420 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32MaxCnrtMa[8] "TLE8242_af32MaxCnrtMa[8]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008424 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32MaxCnrtMa[9] "TLE8242_af32MaxCnrtMa[9]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008428 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32MinCnrtMa "minimum current" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 MATRIX_DIM 15 1 1 ECU_ADDRESS 0x600083C8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32MinCnrtMa[0] "TLE8242_af32MinCnrtMa[0]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600083C8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32MinCnrtMa[10] "TLE8242_af32MinCnrtMa[10]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600083F0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32MinCnrtMa[11] "TLE8242_af32MinCnrtMa[11]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600083F4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32MinCnrtMa[12] "TLE8242_af32MinCnrtMa[12]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600083F8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32MinCnrtMa[13] "TLE8242_af32MinCnrtMa[13]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600083FC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32MinCnrtMa[14] "TLE8242_af32MinCnrtMa[14]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008400 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32MinCnrtMa[1] "TLE8242_af32MinCnrtMa[1]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600083CC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32MinCnrtMa[2] "TLE8242_af32MinCnrtMa[2]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600083D0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32MinCnrtMa[3] "TLE8242_af32MinCnrtMa[3]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600083D4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32MinCnrtMa[4] "TLE8242_af32MinCnrtMa[4]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600083D8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32MinCnrtMa[5] "TLE8242_af32MinCnrtMa[5]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600083DC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32MinCnrtMa[6] "TLE8242_af32MinCnrtMa[6]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600083E0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32MinCnrtMa[7] "TLE8242_af32MinCnrtMa[7]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600083E4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32MinCnrtMa[8] "TLE8242_af32MinCnrtMa[8]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600083E8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32MinCnrtMa[9] "TLE8242_af32MinCnrtMa[9]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600083EC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TarCnrtAftTrimMa "Target current" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 MATRIX_DIM 15 1 1 ECU_ADDRESS 0x60008350 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TarCnrtAftTrimMa[0] "TLE8242_af32TarCnrtAftTrimMa[0]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008350 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TarCnrtAftTrimMa[10] "TLE8242_af32TarCnrtAftTrimMa[10]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008378 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TarCnrtAftTrimMa[11] "TLE8242_af32TarCnrtAftTrimMa[11]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6000837C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TarCnrtAftTrimMa[12] "TLE8242_af32TarCnrtAftTrimMa[12]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008380 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TarCnrtAftTrimMa[13] "TLE8242_af32TarCnrtAftTrimMa[13]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008384 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TarCnrtAftTrimMa[14] "TLE8242_af32TarCnrtAftTrimMa[14]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008388 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TarCnrtAftTrimMa[1] "TLE8242_af32TarCnrtAftTrimMa[1]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008354 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TarCnrtAftTrimMa[2] "TLE8242_af32TarCnrtAftTrimMa[2]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008358 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TarCnrtAftTrimMa[3] "TLE8242_af32TarCnrtAftTrimMa[3]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6000835C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TarCnrtAftTrimMa[4] "TLE8242_af32TarCnrtAftTrimMa[4]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008360 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TarCnrtAftTrimMa[5] "TLE8242_af32TarCnrtAftTrimMa[5]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008364 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TarCnrtAftTrimMa[6] "TLE8242_af32TarCnrtAftTrimMa[6]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008368 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TarCnrtAftTrimMa[7] "TLE8242_af32TarCnrtAftTrimMa[7]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6000836C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TarCnrtAftTrimMa[8] "TLE8242_af32TarCnrtAftTrimMa[8]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008370 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TarCnrtAftTrimMa[9] "TLE8242_af32TarCnrtAftTrimMa[9]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008374 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TarCnrtMa "Target current" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 MATRIX_DIM 15 1 1 ECU_ADDRESS 0x6000838C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TarCnrtMa[0] "TLE8242_af32TarCnrtMa[0]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6000838C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TarCnrtMa[10] "TLE8242_af32TarCnrtMa[10]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600083B4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TarCnrtMa[11] "TLE8242_af32TarCnrtMa[11]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600083B8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TarCnrtMa[12] "TLE8242_af32TarCnrtMa[12]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600083BC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TarCnrtMa[13] "TLE8242_af32TarCnrtMa[13]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600083C0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TarCnrtMa[14] "TLE8242_af32TarCnrtMa[14]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600083C4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TarCnrtMa[1] "TLE8242_af32TarCnrtMa[1]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008390 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TarCnrtMa[2] "TLE8242_af32TarCnrtMa[2]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008394 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TarCnrtMa[3] "TLE8242_af32TarCnrtMa[3]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008398 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TarCnrtMa[4] "TLE8242_af32TarCnrtMa[4]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6000839C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TarCnrtMa[5] "TLE8242_af32TarCnrtMa[5]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600083A0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TarCnrtMa[6] "TLE8242_af32TarCnrtMa[6]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600083A4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TarCnrtMa[7] "TLE8242_af32TarCnrtMa[7]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600083A8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TarCnrtMa[8] "TLE8242_af32TarCnrtMa[8]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600083AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TarCnrtMa[9] "TLE8242_af32TarCnrtMa[9]" FLOAT32_IEEE F_1_p0_35 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600083B0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimGrdtOfFuncGt "TLE8242_af32TrimGrdtOfFuncGt" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 MATRIX_DIM 15 1 1 ECU_ADDRESS 0x600085E4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimGrdtOfFuncGt[0] "TLE8242_af32TrimGrdtOfFuncGt[0]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600085E4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimGrdtOfFuncGt[10] "TLE8242_af32TrimGrdtOfFuncGt[10]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6000860C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimGrdtOfFuncGt[11] "TLE8242_af32TrimGrdtOfFuncGt[11]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008610 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimGrdtOfFuncGt[12] "TLE8242_af32TrimGrdtOfFuncGt[12]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008614 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimGrdtOfFuncGt[13] "TLE8242_af32TrimGrdtOfFuncGt[13]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008618 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimGrdtOfFuncGt[14] "TLE8242_af32TrimGrdtOfFuncGt[14]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6000861C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimGrdtOfFuncGt[1] "TLE8242_af32TrimGrdtOfFuncGt[1]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600085E8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimGrdtOfFuncGt[2] "TLE8242_af32TrimGrdtOfFuncGt[2]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600085EC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimGrdtOfFuncGt[3] "TLE8242_af32TrimGrdtOfFuncGt[3]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600085F0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimGrdtOfFuncGt[4] "TLE8242_af32TrimGrdtOfFuncGt[4]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600085F4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimGrdtOfFuncGt[5] "TLE8242_af32TrimGrdtOfFuncGt[5]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600085F8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimGrdtOfFuncGt[6] "TLE8242_af32TrimGrdtOfFuncGt[6]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600085FC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimGrdtOfFuncGt[7] "TLE8242_af32TrimGrdtOfFuncGt[7]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008600 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimGrdtOfFuncGt[8] "TLE8242_af32TrimGrdtOfFuncGt[8]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008604 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimGrdtOfFuncGt[9] "TLE8242_af32TrimGrdtOfFuncGt[9]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008608 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimGrdtOfFuncOt "TLE8242_af32TrimGrdtOfFuncOt" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 MATRIX_DIM 15 1 1 ECU_ADDRESS 0x600085A8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimGrdtOfFuncOt[0] "TLE8242_af32TrimGrdtOfFuncOt[0]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600085A8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimGrdtOfFuncOt[10] "TLE8242_af32TrimGrdtOfFuncOt[10]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600085D0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimGrdtOfFuncOt[11] "TLE8242_af32TrimGrdtOfFuncOt[11]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600085D4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimGrdtOfFuncOt[12] "TLE8242_af32TrimGrdtOfFuncOt[12]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600085D8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimGrdtOfFuncOt[13] "TLE8242_af32TrimGrdtOfFuncOt[13]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600085DC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimGrdtOfFuncOt[14] "TLE8242_af32TrimGrdtOfFuncOt[14]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600085E0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimGrdtOfFuncOt[1] "TLE8242_af32TrimGrdtOfFuncOt[1]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600085AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimGrdtOfFuncOt[2] "TLE8242_af32TrimGrdtOfFuncOt[2]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600085B0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimGrdtOfFuncOt[3] "TLE8242_af32TrimGrdtOfFuncOt[3]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600085B4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimGrdtOfFuncOt[4] "TLE8242_af32TrimGrdtOfFuncOt[4]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600085B8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimGrdtOfFuncOt[5] "TLE8242_af32TrimGrdtOfFuncOt[5]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600085BC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimGrdtOfFuncOt[6] "TLE8242_af32TrimGrdtOfFuncOt[6]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600085C0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimGrdtOfFuncOt[7] "TLE8242_af32TrimGrdtOfFuncOt[7]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600085C4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimGrdtOfFuncOt[8] "TLE8242_af32TrimGrdtOfFuncOt[8]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600085C8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimGrdtOfFuncOt[9] "TLE8242_af32TrimGrdtOfFuncOt[9]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600085CC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimOffsOfFuncGt "TLE8242_af32TrimOffsOfFuncGt" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 MATRIX_DIM 15 1 1 ECU_ADDRESS 0x60008530 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimOffsOfFuncGt[0] "TLE8242_af32TrimOffsOfFuncGt[0]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008530 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimOffsOfFuncGt[10] "TLE8242_af32TrimOffsOfFuncGt[10]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008558 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimOffsOfFuncGt[11] "TLE8242_af32TrimOffsOfFuncGt[11]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6000855C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimOffsOfFuncGt[12] "TLE8242_af32TrimOffsOfFuncGt[12]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008560 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimOffsOfFuncGt[13] "TLE8242_af32TrimOffsOfFuncGt[13]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008564 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimOffsOfFuncGt[14] "TLE8242_af32TrimOffsOfFuncGt[14]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008568 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimOffsOfFuncGt[1] "TLE8242_af32TrimOffsOfFuncGt[1]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008534 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimOffsOfFuncGt[2] "TLE8242_af32TrimOffsOfFuncGt[2]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008538 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimOffsOfFuncGt[3] "TLE8242_af32TrimOffsOfFuncGt[3]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6000853C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimOffsOfFuncGt[4] "TLE8242_af32TrimOffsOfFuncGt[4]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008540 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimOffsOfFuncGt[5] "TLE8242_af32TrimOffsOfFuncGt[5]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008544 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimOffsOfFuncGt[6] "TLE8242_af32TrimOffsOfFuncGt[6]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008548 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimOffsOfFuncGt[7] "TLE8242_af32TrimOffsOfFuncGt[7]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6000854C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimOffsOfFuncGt[8] "TLE8242_af32TrimOffsOfFuncGt[8]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008550 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimOffsOfFuncGt[9] "TLE8242_af32TrimOffsOfFuncGt[9]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008554 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimOffsOfFuncOt "TLE8242_af32TrimOffsOfFuncOt" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 MATRIX_DIM 15 1 1 ECU_ADDRESS 0x6000856C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimOffsOfFuncOt[0] "TLE8242_af32TrimOffsOfFuncOt[0]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6000856C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimOffsOfFuncOt[10] "TLE8242_af32TrimOffsOfFuncOt[10]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008594 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimOffsOfFuncOt[11] "TLE8242_af32TrimOffsOfFuncOt[11]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008598 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimOffsOfFuncOt[12] "TLE8242_af32TrimOffsOfFuncOt[12]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6000859C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimOffsOfFuncOt[13] "TLE8242_af32TrimOffsOfFuncOt[13]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600085A0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimOffsOfFuncOt[14] "TLE8242_af32TrimOffsOfFuncOt[14]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600085A4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimOffsOfFuncOt[1] "TLE8242_af32TrimOffsOfFuncOt[1]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008570 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimOffsOfFuncOt[2] "TLE8242_af32TrimOffsOfFuncOt[2]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008574 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimOffsOfFuncOt[3] "TLE8242_af32TrimOffsOfFuncOt[3]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008578 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimOffsOfFuncOt[4] "TLE8242_af32TrimOffsOfFuncOt[4]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6000857C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimOffsOfFuncOt[5] "TLE8242_af32TrimOffsOfFuncOt[5]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008580 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimOffsOfFuncOt[6] "TLE8242_af32TrimOffsOfFuncOt[6]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008584 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimOffsOfFuncOt[7] "TLE8242_af32TrimOffsOfFuncOt[7]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008588 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimOffsOfFuncOt[8] "TLE8242_af32TrimOffsOfFuncOt[8]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6000858C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_af32TrimOffsOfFuncOt[9] "TLE8242_af32TrimOffsOfFuncOt[9]" FLOAT32_IEEE F_1_p0_6 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60008590 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8CrntReadChNr "TLE8242_au8CrntReadChNr" UBYTE F_1_p0_6 1 2 0 255 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x600009C0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8CrntReadChNr[0] "TLE8242_au8CrntReadChNr[0]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x600009C0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8CrntReadChNr[1] "TLE8242_au8CrntReadChNr[1]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x600009C1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8CrntReadCnt "TLE8242_au8CrntReadCnt" UWORD F_1_p0_6 1 2 0 65535 MATRIX_DIM 8 2 1 ECU_ADDRESS 0x60007AB8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8CrntReadCnt[0][0] "TLE8242_au8CrntReadCnt[0][0]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007AB8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8CrntReadCnt[0][1] "TLE8242_au8CrntReadCnt[0][1]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007ABA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8CrntReadCnt[0][2] "TLE8242_au8CrntReadCnt[0][2]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007ABC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8CrntReadCnt[0][3] "TLE8242_au8CrntReadCnt[0][3]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007ABE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8CrntReadCnt[0][4] "TLE8242_au8CrntReadCnt[0][4]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007AC0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8CrntReadCnt[0][5] "TLE8242_au8CrntReadCnt[0][5]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007AC2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8CrntReadCnt[0][6] "TLE8242_au8CrntReadCnt[0][6]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007AC4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8CrntReadCnt[0][7] "TLE8242_au8CrntReadCnt[0][7]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007AC6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8CrntReadCnt[1][0] "TLE8242_au8CrntReadCnt[1][0]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007AC8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8CrntReadCnt[1][1] "TLE8242_au8CrntReadCnt[1][1]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007ACA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8CrntReadCnt[1][2] "TLE8242_au8CrntReadCnt[1][2]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007ACC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8CrntReadCnt[1][3] "TLE8242_au8CrntReadCnt[1][3]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007ACE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8CrntReadCnt[1][4] "TLE8242_au8CrntReadCnt[1][4]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007AD0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8CrntReadCnt[1][5] "TLE8242_au8CrntReadCnt[1][5]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007AD2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8CrntReadCnt[1][6] "TLE8242_au8CrntReadCnt[1][6]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007AD4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8CrntReadCnt[1][7] "TLE8242_au8CrntReadCnt[1][7]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007AD6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8CrntVld "TLE8242_au8CrntVld" UBYTE F_1_p0_6 1 2 0 255 MATRIX_DIM 2 2 1 ECU_ADDRESS 0x600009C2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8CrntVld[0][0] "TLE8242_au8CrntVld[0][0]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x600009C2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8CrntVld[0][1] "TLE8242_au8CrntVld[0][1]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x600009C3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8CrntVld[1][0] "TLE8242_au8CrntVld[1][0]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x600009C4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8CrntVld[1][1] "TLE8242_au8CrntVld[1][1]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x600009C5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts "TLE8242_au8FltSts" UWORD F_1_p0_6 1 2 0 65535 MATRIX_DIM 6 15 1 ECU_ADDRESS 0x60007AC8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[0][0] "TLE8242_au8FltSts[0][0]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007AC8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[0][1] "TLE8242_au8FltSts[0][1]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007ACA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[0][2] "TLE8242_au8FltSts[0][2]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007ACC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[0][3] "TLE8242_au8FltSts[0][3]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007ACE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[0][4] "TLE8242_au8FltSts[0][4]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007AD0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[0][5] "TLE8242_au8FltSts[0][5]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007AD2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[10][0] "TLE8242_au8FltSts[10][0]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B40 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[10][1] "TLE8242_au8FltSts[10][1]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B42 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[10][2] "TLE8242_au8FltSts[10][2]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B44 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[10][3] "TLE8242_au8FltSts[10][3]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B46 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[10][4] "TLE8242_au8FltSts[10][4]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B48 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[10][5] "TLE8242_au8FltSts[10][5]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B4A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[11][0] "TLE8242_au8FltSts[11][0]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B4C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[11][1] "TLE8242_au8FltSts[11][1]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B4E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[11][2] "TLE8242_au8FltSts[11][2]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B50 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[11][3] "TLE8242_au8FltSts[11][3]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B52 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[11][4] "TLE8242_au8FltSts[11][4]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B54 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[11][5] "TLE8242_au8FltSts[11][5]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B56 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[12][0] "TLE8242_au8FltSts[12][0]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B58 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[12][1] "TLE8242_au8FltSts[12][1]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B5A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[12][2] "TLE8242_au8FltSts[12][2]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B5C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[12][3] "TLE8242_au8FltSts[12][3]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B5E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[12][4] "TLE8242_au8FltSts[12][4]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B60 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[12][5] "TLE8242_au8FltSts[12][5]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B62 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[13][0] "TLE8242_au8FltSts[13][0]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B64 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[13][1] "TLE8242_au8FltSts[13][1]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B66 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[13][2] "TLE8242_au8FltSts[13][2]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B68 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[13][3] "TLE8242_au8FltSts[13][3]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B6A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[13][4] "TLE8242_au8FltSts[13][4]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B6C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[13][5] "TLE8242_au8FltSts[13][5]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B6E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[14][0] "TLE8242_au8FltSts[14][0]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B70 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[14][1] "TLE8242_au8FltSts[14][1]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B72 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[14][2] "TLE8242_au8FltSts[14][2]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B74 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[14][3] "TLE8242_au8FltSts[14][3]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B76 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[14][4] "TLE8242_au8FltSts[14][4]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B78 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[14][5] "TLE8242_au8FltSts[14][5]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B7A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[1][0] "TLE8242_au8FltSts[1][0]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007AD4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[1][1] "TLE8242_au8FltSts[1][1]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007AD6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[1][2] "TLE8242_au8FltSts[1][2]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007AD8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[1][3] "TLE8242_au8FltSts[1][3]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007ADA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[1][4] "TLE8242_au8FltSts[1][4]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007ADC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[1][5] "TLE8242_au8FltSts[1][5]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007ADE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[2][0] "TLE8242_au8FltSts[2][0]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007AE0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[2][1] "TLE8242_au8FltSts[2][1]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007AE2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[2][2] "TLE8242_au8FltSts[2][2]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007AE4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[2][3] "TLE8242_au8FltSts[2][3]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007AE6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[2][4] "TLE8242_au8FltSts[2][4]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007AE8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[2][5] "TLE8242_au8FltSts[2][5]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007AEA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[3][0] "TLE8242_au8FltSts[3][0]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007AEC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[3][1] "TLE8242_au8FltSts[3][1]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007AEE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[3][2] "TLE8242_au8FltSts[3][2]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007AF0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[3][3] "TLE8242_au8FltSts[3][3]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007AF2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[3][4] "TLE8242_au8FltSts[3][4]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007AF4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[3][5] "TLE8242_au8FltSts[3][5]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007AF6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[4][0] "TLE8242_au8FltSts[4][0]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007AF8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[4][1] "TLE8242_au8FltSts[4][1]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007AFA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[4][2] "TLE8242_au8FltSts[4][2]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007AFC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[4][3] "TLE8242_au8FltSts[4][3]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007AFE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[4][4] "TLE8242_au8FltSts[4][4]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B00 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[4][5] "TLE8242_au8FltSts[4][5]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B02 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[5][0] "TLE8242_au8FltSts[5][0]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B04 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[5][1] "TLE8242_au8FltSts[5][1]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B06 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[5][2] "TLE8242_au8FltSts[5][2]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B08 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[5][3] "TLE8242_au8FltSts[5][3]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B0A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[5][4] "TLE8242_au8FltSts[5][4]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B0C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[5][5] "TLE8242_au8FltSts[5][5]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B0E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[6][0] "TLE8242_au8FltSts[6][0]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B10 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[6][1] "TLE8242_au8FltSts[6][1]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B12 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[6][2] "TLE8242_au8FltSts[6][2]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B14 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[6][3] "TLE8242_au8FltSts[6][3]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B16 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[6][4] "TLE8242_au8FltSts[6][4]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B18 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[6][5] "TLE8242_au8FltSts[6][5]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B1A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[7][0] "TLE8242_au8FltSts[7][0]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B1C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[7][1] "TLE8242_au8FltSts[7][1]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B1E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[7][2] "TLE8242_au8FltSts[7][2]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B20 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[7][3] "TLE8242_au8FltSts[7][3]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B22 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[7][4] "TLE8242_au8FltSts[7][4]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B24 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[7][5] "TLE8242_au8FltSts[7][5]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B26 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[8][0] "TLE8242_au8FltSts[8][0]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B28 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[8][1] "TLE8242_au8FltSts[8][1]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B2A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[8][2] "TLE8242_au8FltSts[8][2]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B2C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[8][3] "TLE8242_au8FltSts[8][3]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B2E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[8][4] "TLE8242_au8FltSts[8][4]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B30 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[8][5] "TLE8242_au8FltSts[8][5]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B32 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[9][0] "TLE8242_au8FltSts[9][0]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B34 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[9][1] "TLE8242_au8FltSts[9][1]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B36 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[9][2] "TLE8242_au8FltSts[9][2]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B38 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[9][3] "TLE8242_au8FltSts[9][3]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B3A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[9][4] "TLE8242_au8FltSts[9][4]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B3C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8FltSts[9][5] "TLE8242_au8FltSts[9][5]" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60007B3E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadLastVal "TLE8242_au8OpenLoadLastVal" UBYTE F_1_p0_6 1 2 0 255 MATRIX_DIM 15 1 1 ECU_ADDRESS 0x6000828C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadLastVal[0] "TLE8242_au8OpenLoadLastVal[0]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x6000828C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadLastVal[10] "TLE8242_au8OpenLoadLastVal[10]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x60008296 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadLastVal[11] "TLE8242_au8OpenLoadLastVal[11]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x60008297 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadLastVal[12] "TLE8242_au8OpenLoadLastVal[12]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x60008298 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadLastVal[13] "TLE8242_au8OpenLoadLastVal[13]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x60008299 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadLastVal[14] "TLE8242_au8OpenLoadLastVal[14]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x6000829A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadLastVal[1] "TLE8242_au8OpenLoadLastVal[1]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x6000828D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadLastVal[2] "TLE8242_au8OpenLoadLastVal[2]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x6000828E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadLastVal[3] "TLE8242_au8OpenLoadLastVal[3]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x6000828F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadLastVal[4] "TLE8242_au8OpenLoadLastVal[4]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x60008290 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadLastVal[5] "TLE8242_au8OpenLoadLastVal[5]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x60008291 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadLastVal[6] "TLE8242_au8OpenLoadLastVal[6]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x60008292 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadLastVal[7] "TLE8242_au8OpenLoadLastVal[7]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x60008293 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadLastVal[8] "TLE8242_au8OpenLoadLastVal[8]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x60008294 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadLastVal[9] "TLE8242_au8OpenLoadLastVal[9]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x60008295 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadMaxReadCnt "TLE8242_au8OpenLoadMaxReadCnt" UBYTE F_1_p0_6 1 2 0 255 MATRIX_DIM 15 1 1 ECU_ADDRESS 0x600082AA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadMaxReadCnt[0] "TLE8242_au8OpenLoadMaxReadCnt[0]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x600082AA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadMaxReadCnt[10] "TLE8242_au8OpenLoadMaxReadCnt[10]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x600082B4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadMaxReadCnt[11] "TLE8242_au8OpenLoadMaxReadCnt[11]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x600082B5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadMaxReadCnt[12] "TLE8242_au8OpenLoadMaxReadCnt[12]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x600082B6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadMaxReadCnt[13] "TLE8242_au8OpenLoadMaxReadCnt[13]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x600082B7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadMaxReadCnt[14] "TLE8242_au8OpenLoadMaxReadCnt[14]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x600082B8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadMaxReadCnt[1] "TLE8242_au8OpenLoadMaxReadCnt[1]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x600082AB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadMaxReadCnt[2] "TLE8242_au8OpenLoadMaxReadCnt[2]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x600082AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadMaxReadCnt[3] "TLE8242_au8OpenLoadMaxReadCnt[3]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x600082AD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadMaxReadCnt[4] "TLE8242_au8OpenLoadMaxReadCnt[4]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x600082AE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadMaxReadCnt[5] "TLE8242_au8OpenLoadMaxReadCnt[5]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x600082AF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadMaxReadCnt[6] "TLE8242_au8OpenLoadMaxReadCnt[6]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x600082B0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadMaxReadCnt[7] "TLE8242_au8OpenLoadMaxReadCnt[7]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x600082B1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadMaxReadCnt[8] "TLE8242_au8OpenLoadMaxReadCnt[8]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x600082B2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadMaxReadCnt[9] "TLE8242_au8OpenLoadMaxReadCnt[9]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x600082B3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadReadCnt "TLE8242_au8OpenLoadReadCnt" UBYTE F_1_p0_6 1 2 0 255 MATRIX_DIM 15 1 1 ECU_ADDRESS 0x6000829B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadReadCnt[0] "TLE8242_au8OpenLoadReadCnt[0]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x6000829B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadReadCnt[10] "TLE8242_au8OpenLoadReadCnt[10]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x600082A5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadReadCnt[11] "TLE8242_au8OpenLoadReadCnt[11]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x600082A6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadReadCnt[12] "TLE8242_au8OpenLoadReadCnt[12]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x600082A7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadReadCnt[13] "TLE8242_au8OpenLoadReadCnt[13]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x600082A8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadReadCnt[14] "TLE8242_au8OpenLoadReadCnt[14]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x600082A9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadReadCnt[1] "TLE8242_au8OpenLoadReadCnt[1]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x6000829C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadReadCnt[2] "TLE8242_au8OpenLoadReadCnt[2]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x6000829D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadReadCnt[3] "TLE8242_au8OpenLoadReadCnt[3]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x6000829E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadReadCnt[4] "TLE8242_au8OpenLoadReadCnt[4]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x6000829F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadReadCnt[5] "TLE8242_au8OpenLoadReadCnt[5]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x600082A0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadReadCnt[6] "TLE8242_au8OpenLoadReadCnt[6]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x600082A1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadReadCnt[7] "TLE8242_au8OpenLoadReadCnt[7]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x600082A2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadReadCnt[8] "TLE8242_au8OpenLoadReadCnt[8]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x600082A3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadReadCnt[9] "TLE8242_au8OpenLoadReadCnt[9]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x600082A4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadRealVal "TLE8242_au8OpenLoadRealVal" UBYTE F_1_p0_6 1 2 0 255 MATRIX_DIM 15 1 1 ECU_ADDRESS 0x6000827D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadRealVal[0] "TLE8242_au8OpenLoadRealVal[0]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x6000827D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadRealVal[10] "TLE8242_au8OpenLoadRealVal[10]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x60008287 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadRealVal[11] "TLE8242_au8OpenLoadRealVal[11]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x60008288 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadRealVal[12] "TLE8242_au8OpenLoadRealVal[12]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x60008289 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadRealVal[13] "TLE8242_au8OpenLoadRealVal[13]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x6000828A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadRealVal[14] "TLE8242_au8OpenLoadRealVal[14]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x6000828B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadRealVal[1] "TLE8242_au8OpenLoadRealVal[1]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x6000827E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadRealVal[2] "TLE8242_au8OpenLoadRealVal[2]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x6000827F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadRealVal[3] "TLE8242_au8OpenLoadRealVal[3]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x60008280 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadRealVal[4] "TLE8242_au8OpenLoadRealVal[4]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x60008281 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadRealVal[5] "TLE8242_au8OpenLoadRealVal[5]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x60008282 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadRealVal[6] "TLE8242_au8OpenLoadRealVal[6]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x60008283 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadRealVal[7] "TLE8242_au8OpenLoadRealVal[7]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x60008284 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadRealVal[8] "TLE8242_au8OpenLoadRealVal[8]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x60008285 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8OpenLoadRealVal[9] "TLE8242_au8OpenLoadRealVal[9]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x60008286 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8PwmOffs "TLE8242_au8PwmOffs" UBYTE F_1_p0_6 1 2 0 255 MATRIX_DIM 15 1 1 ECU_ADDRESS 0x60006788 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8PwmOffs[0] "TLE8242_au8PwmOffs[0]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x60006788 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8PwmOffs[10] "TLE8242_au8PwmOffs[10]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x60006792 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8PwmOffs[11] "TLE8242_au8PwmOffs[11]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x60006793 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8PwmOffs[12] "TLE8242_au8PwmOffs[12]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x60006794 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8PwmOffs[13] "TLE8242_au8PwmOffs[13]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x60006795 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8PwmOffs[14] "TLE8242_au8PwmOffs[14]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x60006796 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8PwmOffs[1] "TLE8242_au8PwmOffs[1]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x60006789 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8PwmOffs[2] "TLE8242_au8PwmOffs[2]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x6000678A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8PwmOffs[3] "TLE8242_au8PwmOffs[3]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x6000678B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8PwmOffs[4] "TLE8242_au8PwmOffs[4]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x6000678C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8PwmOffs[5] "TLE8242_au8PwmOffs[5]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x6000678D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8PwmOffs[6] "TLE8242_au8PwmOffs[6]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x6000678E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8PwmOffs[7] "TLE8242_au8PwmOffs[7]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x6000678F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8PwmOffs[8] "TLE8242_au8PwmOffs[8]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x60006790 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_au8PwmOffs[9] "TLE8242_au8PwmOffs[9]" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x60006791 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLE8242_u8ErrMsgRevCnt "TLE8242_u8ErrMsgRevCnt" UBYTE F_1_p0_6 1 2 0 255 ECU_ADDRESS 0x600009B4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLF35584_audtRegSt "TLF35584_audtRegSt" UBYTE F_1_p0_7 1 2 0 255 MATRIX_DIM 13 1 1 ECU_ADDRESS 0x60008950 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLF35584_audtRegSt[0] "TLF35584_audtRegSt[0]" UBYTE F_1_p0_7 1 2 0 255 ECU_ADDRESS 0x60008950 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLF35584_audtRegSt[10] "TLF35584_audtRegSt[10]" UBYTE F_1_p0_7 1 2 0 255 ECU_ADDRESS 0x6000895A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLF35584_audtRegSt[11] "TLF35584_audtRegSt[11]" UBYTE F_1_p0_7 1 2 0 255 ECU_ADDRESS 0x6000895B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLF35584_audtRegSt[12] "TLF35584_audtRegSt[12]" UBYTE F_1_p0_7 1 2 0 255 ECU_ADDRESS 0x6000895C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLF35584_audtRegSt[1] "TLF35584_audtRegSt[1]" UBYTE F_1_p0_7 1 2 0 255 ECU_ADDRESS 0x60008951 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLF35584_audtRegSt[2] "TLF35584_audtRegSt[2]" UBYTE F_1_p0_7 1 2 0 255 ECU_ADDRESS 0x60008952 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLF35584_audtRegSt[3] "TLF35584_audtRegSt[3]" UBYTE F_1_p0_7 1 2 0 255 ECU_ADDRESS 0x60008953 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLF35584_audtRegSt[4] "TLF35584_audtRegSt[4]" UBYTE F_1_p0_7 1 2 0 255 ECU_ADDRESS 0x60008954 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLF35584_audtRegSt[5] "TLF35584_audtRegSt[5]" UBYTE F_1_p0_7 1 2 0 255 ECU_ADDRESS 0x60008955 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLF35584_audtRegSt[6] "TLF35584_audtRegSt[6]" UBYTE F_1_p0_7 1 2 0 255 ECU_ADDRESS 0x60008956 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLF35584_audtRegSt[7] "TLF35584_audtRegSt[7]" UBYTE F_1_p0_7 1 2 0 255 ECU_ADDRESS 0x60008957 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLF35584_audtRegSt[8] "TLF35584_audtRegSt[8]" UBYTE F_1_p0_7 1 2 0 255 ECU_ADDRESS 0x60008958 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TLF35584_audtRegSt[9] "TLF35584_audtRegSt[9]" UBYTE F_1_p0_7 1 2 0 255 ECU_ADDRESS 0x60008959 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_DET_u16ModuleId "TST_DET_u16ModuleId" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x600151C0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_DET_u16NbOfRecordToAdd "TST_DET_u16NbOfRecordToAdd" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x600151BC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_DET_u8ApiId "TST_DET_u8ApiId" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600151CC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_DET_u8ErrorId "TST_DET_u8ErrorId" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600151C8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_DET_u8InstanceId "TST_DET_u8InstanceId" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600151C4 READ_WRITE /end MEASUREMENT
/begin COMPU_METHOD I_5 "" RAT_FUNC "%9.2" "-" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD F_1_p0_6 "" RAT_FUNC "%9.2" "-" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD F_1_p0_7 "" RAT_FUNC "%9.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD F_0v0061035156_p0_26 "" RAT_FUNC "%9.3" "%" COEFFS 0 1 0 0 0 0.00610352 /end COMPU_METHOD
/begin COMPU_METHOD F_0v0625_p0_34 "" RAT_FUNC "%9.2" "�C" COEFFS 0 1 0 0 0 0.0625 /end COMPU_METHOD
/begin COMPU_METHOD F_1_p0_35 "" RAT_FUNC "%9.2" "mA" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD F_1_p0_37 "" RAT_FUNC "%9.2" "Hz" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Id_0x00 "" RAT_FUNC "%9.2" "." COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Bool_ON_OFF "" TAB_VERB "%8.4" "." COMPU_TAB_REF Bool_ON_OFF_table /end COMPU_METHOD
/begin COMPU_VTAB Bool_ON_OFF_table "" TAB_VERB 2 0 "OFF" 1 "ON" /end COMPU_VTAB
/begin FUNCTION SWTST "" FUNCTION_VERSION "NONE_"
 /begin DEF_CHARACTERISTIC SWTST_kbDioWrSolenoidHsCmd2 SWTST_kbDioWrSolenoidHsCmd3 SWTST_kbDioWrSolenoidHsCmd4 SWTST_kbDioWrSolenoidHsDen1 SWTST_kbDioWrSolenoidHsDen2 SWTST_kbDioWrSolenoidHsDen3 SWTST_kbDioWrSolenoidHsDen4 SWTST_kbDioWrSupplyWdi SWTST_kbEVPTstEnaC SWTST_kbFimTstEnaC SWTST_kbPwmTstEnaC SWTST_kbSftyTstEnaC SWTST_kbTle62X0TstEnaC SWTST_kbTle62X0WrOutLsd1 SWTST_kbTle62X0WrOutLsd10 SWTST_kbTle62X0WrOutLsd11 SWTST_kbTle62X0WrOutLsd12 SWTST_kbTle62X0WrOutLsd2 SWTST_kbTle62X0WrOutLsd3 SWTST_kbTle62X0WrOutLsd4 SWTST_kbTle62X0WrOutLsd5 SWTST_kbTle62X0WrOutLsd6 SWTST_kbTle62X0WrOutLsd7 SWTST_kbTle62X0WrOutLsd8 SWTST_kbTle62X0WrOutLsd9 SWTST_kbTLE8242TstEnaC SWTST_kbTrimTstEnaC SWTST_kbWdgTstEnaC SWTST_kf32ComWrEbc1Sa03BrakePedalPos SWTST_kf32ComWrEbc1Sa03EngRetarderSelection SWTST_kf32ComWrErc1Sa16ActlMxAvlblRetarderPercentTorque SWTST_kf32ComWrErc1Sa16ActualRetarderPercentTorque SWTST_kf32ComWrErc1Sa16DrvrsDemandRetarderPercentTorque SWTST_kf32ComWrErc1Sa16IntendedRetarderPercentTorque SWTST_kf32ComWrErc1Sa16RetarderSelectionNonengine SWTST_kf32ComWrEtc1Sa03PercentClutchSlip SWTST_kf32ComWrEtc1Sa03TransInputShaftSpeed SWTST_kf32ComWrEtc1Sa03TransOutputShaftSpeed SWTST_kf32ComWrEtc2Sa03TransActualGearRatio SWTST_kf32ComWrEtc8Sa03TransClutchConverterInputSpeed SWTST_kf32ComWrEtc8Sa03TransTorqueConverterRatio SWTST_kf32ComWrRcSa16MaxRetarderSpeedPoint2 SWTST_kf32ComWrRcSa16PercentTorqueAtIdlePoint1 SWTST_kf32ComWrRcSa16PercentTorqueAtMaxSpeedPoint2 SWTST_kf32ComWrRcSa16PercentTorqueAtPeakTorquePoint5 SWTST_kf32ComWrRcSa16PercentTorqueAtPoint3 SWTST_kf32ComWrRcSa16PercentTorqueAtPoint4 SWTST_kf32ComWrRcSa16ReferenceRetarderTorque SWTST_kf32ComWrRcSa16RetarderSpeedAtIdlePoint1 SWTST_kf32ComWrRcSa16RetarderSpeedAtPeakTorquePoint5 SWTST_kf32ComWrRcSa16RetarderSpeedAtPoint3 SWTST_kf32ComWrRcSa16RetarderSpeedAtPoint4 SWTST_kf32ComWrRfSa16HydRetarderOilTemp SWTST_kf32ComWrRfSa16HydRetarderPress SWTST_kf32ComWrRfSa16RetarderCoolantOutletTemp SWTST_kf32ComWrTcfg2Sa03TransTorqueLimit SWTST_kf32ComWrTcfgSa03NumberOfForwardGearRatios SWTST_kf32ComWrTcfgSa03NumberOfReverseGearRatios SWTST_kf32ComWrTcfgSa03TransGearRatio SWTST_kf32ComWrTrf1Sa03ClutchPress SWTST_kf32ComWrTrf1Sa03TransFilterDiffPress SWTST_kf32ComWrTrf1Sa03TransOilLevel1 SWTST_kf32ComWrTrf1Sa03TransOilLevel1HighLow SWTST_kf32ComWrTrf1Sa03TransOilPress SWTST_kf32ComWrTrf1Sa03TransOilTemp1 SWTST_kf32ComWrTrf2Sa03TransOilLevel2HighLow SWTST_kf32ComWrTrf2Sa03TransOilLifeRemaining SWTST_kf32ComWrTrf2Sa03TransOilTemp2 SWTST_kf32ComWrTrf2Sa03TrnsTorqueConverterOilOutletTemp SWTST_kf32ComWrTsc1Sa03EngRequestedSpeedSpeedLimit SWTST_kf32ComWrTsc1Sa03EngRequestedTorqueHighResolution SWTST_kf32ComWrTsc1Sa03EngRequestedTorqueTorqueLimit SWTST_kf32ComWrTxDBStaMCU1Sa240TxDBTempMCU SWTST_kf32ComWrTxDBStaMCU1Sa240TxDBTempMot SWTST_kf32ComWrTxDBStaMCU2Sa240TxDBPowerMot SWTST_kf32ComWrTxDBStaMCU2Sa240TxDBTrqMot SWTST_kf32ComWrTxDBStaVCU1Sa208TxDBVehVelocity SWTST_kf32ComWrTxDBStaVCU2Sa208TxDBAccPedlPos SWTST_kf32ComWrTxDBStaVCU2Sa208TxDBBrakPedlPos SWTST_kf32ComWrTxDBStaVCU2Sa208TxDBDistancePerCharge SWTST_kf32ComWrTxDBStaVCU2Sa208TxDBVcuVersion SWTST_kf32ComWrTxMCUCmdSa208TxMCULimitHigh SWTST_kf32ComWrTxMCUCmdSa208TxMCULimitLow SWTST_kf32ComWrTxMCUCmdSa208TxMCUMotTargetSpd SWTST_kf32ComWrTxMCUCmdSa208TxMCUMotTargetTrq SWTST_kf32ComWrTxMultCtrlSa208TxMultCtrlCANGivenSpd SWTST_ks8ComWrEtc2Sa03TransCurrentGear SWTST_ks8ComWrEtc2Sa03TransSelectedGear SWTST_ks8ComWrEtc7Sa03TransRequestedGearFeedback SWTST_ku16ComWrEtc2Sa03TransCurrentRange SWTST_ku16ComWrEtc2Sa03TransRequestedRange SWTST_ku16ComWrTxDBStaMCU1Sa240TxDBBusVolt SWTST_ku16ComWrTxDBStaMCU2Sa240TxDBSpdMot SWTST_ku8AdcTstNrC SWTST_ku8Btt6020TstNrC SWTST_ku8CalibTstNrC SWTST_ku8ComTstNrC SWTST_ku8ComWrCiSa03CptIdn SWTST_ku8ComWrEbc1Sa03ABSEBSAmberWarningSignal SWTST_ku8ComWrEbc1Sa03ABSFullyOperational SWTST_ku8ComWrEbc1Sa03ABSOffroadSwitch SWTST_ku8ComWrEbc1Sa03AccelInterlockSwitch SWTST_ku8ComWrEbc1Sa03AntiLockBrakingActive SWTST_ku8ComWrEbc1Sa03ASRBrakeCtrlActive SWTST_ku8ComWrEbc1Sa03ASREngCtrlActive SWTST_ku8ComWrEbc1Sa03ASRHillHolderSwitch SWTST_ku8ComWrEbc1Sa03ASROffroadSwitch SWTST_ku8ComWrEbc1Sa03ATCASRInformationSignal SWTST_ku8ComWrEbc1Sa03EBSBrakeSwitch SWTST_ku8ComWrEbc1Sa03EBSRedWarningSignal SWTST_ku8ComWrEbc1Sa03EngAuxShutdownSwitch SWTST_ku8ComWrEbc1Sa03EngDerateSwitch SWTST_ku8ComWrEbc1Sa03HaltBrakeSwitch SWTST_ku8ComWrEbc1Sa03RemoteAccelEnableSwitch SWTST_ku8ComWrEbc1Sa03SrcAddrssOfCntrllngDvcFrBrkeCtrl SWTST_ku8ComWrEbc1Sa03TractionCtrlOverrideSwitch SWTST_ku8ComWrEbc1Sa03TrailerABSStatus SWTST_ku8ComWrEbc1Sa03TrctrMntdTrailerABSWarningSignal SWTST_ku8ComWrErc1Sa16EngCoolantLoadIncrease SWTST_ku8ComWrErc1Sa16RetarderEnableBrakeAssistSwitch SWTST_ku8ComWrErc1Sa16RetarderEnableShiftAssistSwitch SWTST_ku8ComWrErc1Sa16RetarderRequestingBrakeLight SWTST_ku8ComWrErc1Sa16RetarderRoadSpeedExceededStatus SWTST_ku8ComWrErc1Sa16RetarderRoadSpeedLimitSwitch SWTST_ku8ComWrErc1Sa16RetarderTorqueMode SWTST_ku8ComWrErc1Sa16SrcAddrssOfCntrllngDvcFrRtrdrCtr SWTST_ku8ComWrEtc1Sa03EngMomentaryOverspeedEnable SWTST_ku8ComWrEtc1Sa03MomentaryEngMaxPowerEnable SWTST_ku8ComWrEtc1Sa03ProgressiveShiftDisable SWTST_ku8ComWrEtc1Sa03SrcAddrssOfCntrllngDvcFrTrnsCtrl SWTST_ku8ComWrEtc1Sa03TransDrivelineEngaged SWTST_ku8ComWrEtc1Sa03TransShiftInProcess SWTST_ku8ComWrEtc1Sa03TrnsTorqueConverterLockupEngaged SWTST_ku8ComWrEtc1Sa03TrnsTrqCnvrtrLckpTrnstnInProcess SWTST_ku8ComWrEtc7Sa03ActiveShiftConsoleIndicator SWTST_ku8ComWrEtc7Sa03TransAirSupplyPressIndicator SWTST_ku8ComWrEtc7Sa03TransAutoNeutralSt SWTST_ku8ComWrEtc7Sa03TransEngCrankEnable SWTST_ku8ComWrEtc7Sa03TransMode10Indicator SWTST_ku8ComWrEtc7Sa03TransMode1Indicator SWTST_ku8ComWrEtc7Sa03TransMode2Indicator SWTST_ku8ComWrEtc7Sa03TransMode3Indicator SWTST_ku8ComWrEtc7Sa03TransMode4Indicator SWTST_ku8ComWrEtc7Sa03TransMode5Indicator SWTST_ku8ComWrEtc7Sa03TransMode6Indicator SWTST_ku8ComWrEtc7Sa03TransMode7Indicator SWTST_ku8ComWrEtc7Sa03TransMode8Indicator SWTST_ku8ComWrEtc7Sa03TransMode9Indicator SWTST_ku8ComWrEtc7Sa03TransReadyForBrakeRelease SWTST_ku8ComWrEtc7Sa03TransServiceIndicator SWTST_ku8ComWrEtc7Sa03TransShiftInhibitIndicator SWTST_ku8ComWrEtc7Sa03TransWarningIndicator SWTST_ku8ComWrEtc7Sa03TrnsCrrentRangeDisplayBlankState SWTST_ku8ComWrEtc7Sa03TrnsRqstedRangeDisplayBlankState SWTST_ku8ComWrEtc7Sa03TrnsRqstedRangeDisplayFlashState SWTST_ku8ComWrEtc7Sa03TrnsRverseGearShiftInhibitStatus SWTST_ku8ComWrJ2012Sa03J2012DTCOccurrenceCount SWTST_ku8ComWrJ2012Sa03J2012DTCStatus SWTST_ku8ComWrJ2012Sa03NumberOfJ2012DTCs SWTST_ku8ComWrPtodeSa03AtLeastOnePTOEngaged SWTST_ku8ComWrPtodeSa03EnableSwitchPTOEngFlywheel SWTST_ku8ComWrPtodeSa03EnableSwitchTransInputShaftPTO1 SWTST_ku8ComWrPtodeSa03EnableSwitchTransInputShaftPTO2 SWTST_ku8ComWrPtodeSa03EnableSwitchTransOutputShaftPTO SWTST_ku8ComWrPtodeSa03EnbleSwitchPTOEngAccessoryDrive1 SWTST_ku8ComWrPtodeSa03EnbleSwitchPTOEngAccessoryDrive2 SWTST_ku8ComWrPtodeSa03EnblSwtchTrnsfrCseOutputShaftPTO SWTST_ku8ComWrPtodeSa03EngagementConsentPTOEngFlywheel SWTST_ku8ComWrPtodeSa03EngagementStatusPTOEngFlywheel SWTST_ku8ComWrPtodeSa03EnggmntCnsentTransInputShaftPTO1 SWTST_ku8ComWrPtodeSa03EnggmntCnsentTransInputShaftPTO2 SWTST_ku8ComWrPtodeSa03EnggmntCnsentTransOutputShaftPTO SWTST_ku8ComWrPtodeSa03EnggmntCnsntPTOEngAccssoryDrive1 SWTST_ku8ComWrPtodeSa03EnggmntCnsntPTOEngAccssoryDrive2 SWTST_ku8ComWrPtodeSa03EnggmntCnsntTrnsfrCsOtptShaftPTO SWTST_ku8ComWrPtodeSa03EnggmntStatusTransInputShaftPTO1 SWTST_ku8ComWrPtodeSa03EnggmntStatusTransInputShaftPTO2 SWTST_ku8ComWrPtodeSa03EnggmntStatusTransOutputShaftPTO SWTST_ku8ComWrPtodeSa03EnggmntSttsPTOEngAccessoryDrive1 SWTST_ku8ComWrPtodeSa03EnggmntSttsPTOEngAccessoryDrive2 SWTST_ku8ComWrPtodeSa03EnggmntSttsTrnsfrCsOtputShaftPTO SWTST_ku8ComWrRcSa16RetarderCtrlMethod SWTST_ku8ComWrRcSa16RetarderLocation SWTST_ku8ComWrRcSa16RetarderType SWTST_ku8ComWrRfSa16DrvlineRetarderOverheatIndicator SWTST_ku8ComWrSoft SWTST_ku8ComWrSOFTSa254NmbrOfSftwreIdentificationFields SWTST_ku8ComWrSOFTSa254SoftwareIdentification SWTST_ku8ComWrTrf1Sa03TransOilLevel1CountdownTimer SWTST_ku8ComWrTrf1Sa03TransOilLevel1MeasurementStatus SWTST_ku8ComWrTrf2Sa03TransOilFilterRestrictionSwitch SWTST_ku8ComWrTrf2Sa03TransOilLevel2CountdownTimer SWTST_ku8ComWrTrf2Sa03TransOilLevel2MeasurementStatus SWTST_ku8ComWrTrf2Sa03TransOilLevelSwitch SWTST_ku8ComWrTrf2Sa03TransOverheatIndicator SWTST_ku8ComWrTsc1Sa03EngOverrideCtrlMode SWTST_ku8ComWrTsc1Sa03EngRequestedSpeedCtrlConditions SWTST_ku8ComWrTsc1Sa03MessageChecksum SWTST_ku8ComWrTsc1Sa03MessageCounter SWTST_ku8ComWrTsc1Sa03OverrideCtrlModePriority SWTST_ku8ComWrTsc1Sa03TSC1CtrlPurpose SWTST_ku8ComWrTsc1Sa03TSC1TransRate SWTST_ku8ComWrTxDBHVAttachSa208cntTCU SWTST_ku8ComWrTxDBHVAttachSa208TxDBBrkPumpSta SWTST_ku8ComWrTxDBHVAttachSa208TxDBDCDCSta SWTST_ku8ComWrTxDBHVAttachSa208TxDBSteerPumpSta SWTST_ku8ComWrTxDBHVAttachSa208TxDBUrgentSwitch SWTST_ku8ComWrTxDBHVBoardSa208TxDBAirCondErr SWTST_ku8ComWrTxDBHVBoardSa208TxDBDefrostErr SWTST_ku8ComWrTxDBHVBoardSa208TxDBEleAttErr SWTST_ku8ComWrTxDBHVBoardSa208TxDBEleAttPreChargeErr SWTST_ku8ComWrTxDBHVBoardSa208TxDBEleAttPreChargeSta SWTST_ku8ComWrTxDBHVBoardSa208TxDBEleAttSta SWTST_ku8ComWrTxDBHVBoardSa208TxDBMainMotErr SWTST_ku8ComWrTxDBHVBoardSa208TxDBMainMotSta SWTST_ku8ComWrTxDBHVBoardSa208TxDBMainPreChargeErr SWTST_ku8ComWrTxDBHVBoardSa208TxDBMainPreChargeSta SWTST_ku8ComWrTxDBHVBoardSa208TxDBPtcErr SWTST_ku8ComWrTxDBStaMCU1Sa240TxDBBraCtrlSta SWTST_ku8ComWrTxDBStaMCU1Sa240TxDBCANErrWarn SWTST_ku8ComWrTxDBStaMCU1Sa240TxDBDriCtrlSta SWTST_ku8ComWrTxDBStaMCU1Sa240TxDBErrCode SWTST_ku8ComWrTxDBStaMCU1Sa240TxDBErrSta SWTST_ku8ComWrTxDBStaMCU1Sa240TxDBMCUTempWarn SWTST_ku8ComWrTxDBStaMCU1Sa240TxDBMotTempWarn SWTST_ku8ComWrTxDBStaMCU1Sa240TxDBOverCurrWarn SWTST_ku8ComWrTxDBStaMCU1Sa240TxDBOverVoltWarn SWTST_ku8ComWrTxDBStaMCU1Sa240TxDBRevCtrlSta SWTST_ku8ComWrTxDBStaMCU1Sa240TxDBSelfCheckCtrlSta SWTST_ku8ComWrTxDBStaMCU1Sa240TxDBUnderVoltWarn SWTST_ku8ComWrTxDBStaVCU1Sa208TxDBCanErr SWTST_ku8ComWrTxDBStaVCU1Sa208TxDBGearCurrNum SWTST_ku8ComWrTxDBStaVCU1Sa208TxDBInterLock SWTST_ku8ComWrTxDBStaVCU1Sa208TxDBStaBmsRelay SWTST_ku8ComWrTxDBStaVCU1Sa208TxDBStaVeh SWTST_ku8ComWrTxDBStaVCU1Sa208TxDBTransErr SWTST_ku8ComWrTxDBStaVCU1Sa208TxDBVcuCnt SWTST_ku8ComWrTxDBStaVCU1Sa208TxDBVcuErr SWTST_ku8ComWrTxDBStaVCU1Sa208TxDBVcuErrCode SWTST_ku8ComWrTxDBStaVCU1Sa208TxDBVcuSelfCheck SWTST_ku8ComWrTxMCUCmdSa208TxMCUFaultReset SWTST_ku8ComWrTxMCUCmdSa208TxMCULiveCounter SWTST_ku8ComWrTxMCUCmdSa208TxMCUMotCtrlModeCmd SWTST_ku8ComWrTxMCUCmdSa208TxMCUMotStaCmd SWTST_ku8ComWrTxMultCtrlSa208TxMultCtrlBrkPumpCmd SWTST_ku8ComWrTxMultCtrlSa208TxMultCtrlMotHVCmd SWTST_ku8ComWrTxMultCtrlSa208TxMultCtrlSteerPumpCmd SWTST_ku8DiagcTstNrC SWTST_ku8DioTstNrC SWTST_ku8FimTstNrC SWTST_ku8SftySubTstNrC SWTST_ku8SftyTstNrC SWTST_ku8Tle62X0TstNrC SWTST_ku8Tle8242TstNrC SWTST_ku8TrimTstNrC SWTST_ku8WdgTstNrC SWTST_u8TLE8242_LINEAR_VALVE_1_1_PwmOffs SWTST_u8TLE8242_LINEAR_VALVE_1_2_PwmOffs SWTST_u8TLE8242_LINEAR_VALVE_2_3_PwmOffs SWTST_u8TLE8242_LINEAR_VALVE_2_4_PwmOffs SWTST_u8TLE8242_LINEAR_VALVE_2_5_PwmOffs SWTST_u8TLE8242_LINEAR_VALVE_3_6_PwmOffs SWTST_u8TLE8242_LINEAR_VALVE_3_7_PwmOffs SWTST_u8TLE8242_LINEAR_VALVE_3_8_PwmOffs SWTST_u8TLE8242_LINEAR_VALVE_4_10_PwmOffs SWTST_u8TLE8242_LINEAR_VALVE_4_9_PwmOffs SWTST_u8TLE8242_PWM_VALVE_1_1_PwmOffs SWTST_u8TLE8242_PWM_VALVE_1_2_PwmOffs SWTST_u8TLE8242_PWM_VALVE_1_3_PwmOffs SWTST_u8TLE8242_PWM_VALVE_4_4_PwmOffs SWTST_u8TLE8242_PWM_VALVE_4_5_PwmOffs TST_PWM_bPWM_ENA_SPEEDOMETER TST_PWM_s16PWM_DUTY_SPEEDOMETER TST_PWM_u32PWM_FRQ_SPEEDOMETER /end DEF_CHARACTERISTIC
/end FUNCTION
/begin FUNCTION SpdSnsrDirDetn "" FUNCTION_VERSION "NONE_" /begin DEF_CHARACTERISTIC SPDSNSRSIRSETN_u8DirCtrl /end DEF_CHARACTERISTIC /begin OUT_MEASUREMENT SPDSNSRSIRSETN_enuDir /end OUT_MEASUREMENT /end FUNCTION
/begin FUNCTION TEMP "" FUNCTION_VERSION "NONE_"
 /begin DEF_CHARACTERISTIC TEMP_ks16TempDeltaMaxThd TEMP_ks16TempDeltaMinThd TEMP_ks16TempDieMaxThd TEMP_ks16TempDieMinThd TEMP_ks16TempPcbMaxThd TEMP_ks16TempPcbMinThd /end DEF_CHARACTERISTIC
 /begin OUT_MEASUREMENT TEMP_s16PhysTempDie TEMP_s16PhysTempPcb /end OUT_MEASUREMENT
/end FUNCTION
/begin FUNCTION TLE8242 "" FUNCTION_VERSION "NONE_"
 /begin DEF_CHARACTERISTIC BTT6020_kf32HsdOcFltLsdCrntThd BTT6020_kf32LsdScFltThd TLE8242_kaf32DutyCycle TLE8242_kau16KI TLE8242_kau16KP TLE8242_kau8OpenLoop TLE8242_kau8ReadCrntRetMax TLE8242_kf32ChopperFrqMaxThd TLE8242_kf32ChopperFrqMinThd TLE8242_kf32MinChgForCrnt TLE8242_kf32MinChgForFrqPrm TLE8242_kf32OverUnderLoadThd TLE8242_kf32R_Shunt TLE8242_kf32TrimGrdtOfFuncGt TLE8242_kf32TrimGrdtOfFuncOt TLE8242_kf32TrimOffsOfFuncGt TLE8242_kf32TrimOffsOfFuncOt TLE8242_ku8AutoZeroEna /end DEF_CHARACTERISTIC
 /begin OUT_MEASUREMENT TLE8242_abDitherAmplCompRes TLE8242_abDitherAmplCompRes[0] TLE8242_abDitherAmplCompRes[10] TLE8242_abDitherAmplCompRes[11] TLE8242_abDitherAmplCompRes[12] TLE8242_abDitherAmplCompRes[13] TLE8242_abDitherAmplCompRes[14] TLE8242_abDitherAmplCompRes[1] TLE8242_abDitherAmplCompRes[2] TLE8242_abDitherAmplCompRes[3] TLE8242_abDitherAmplCompRes[4] TLE8242_abDitherAmplCompRes[5] TLE8242_abDitherAmplCompRes[6] TLE8242_abDitherAmplCompRes[7] TLE8242_abDitherAmplCompRes[8] TLE8242_abDitherAmplCompRes[9] TLE8242_abDitherFrqCompRes TLE8242_abDitherFrqCompRes[0] TLE8242_abDitherFrqCompRes[10] TLE8242_abDitherFrqCompRes[11] TLE8242_abDitherFrqCompRes[12] TLE8242_abDitherFrqCompRes[13] TLE8242_abDitherFrqCompRes[14] TLE8242_abDitherFrqCompRes[1] TLE8242_abDitherFrqCompRes[2] TLE8242_abDitherFrqCompRes[3] TLE8242_abDitherFrqCompRes[4] TLE8242_abDitherFrqCompRes[5] TLE8242_abDitherFrqCompRes[6] TLE8242_abDitherFrqCompRes[7] TLE8242_abDitherFrqCompRes[8] TLE8242_abDitherFrqCompRes[9] TLE8242_abTarCrntCompRes TLE8242_abTarCrntCompRes[0] TLE8242_abTarCrntCompRes[10] TLE8242_abTarCrntCompRes[11] TLE8242_abTarCrntCompRes[12] TLE8242_abTarCrntCompRes[13] TLE8242_abTarCrntCompRes[14] TLE8242_abTarCrntCompRes[1] TLE8242_abTarCrntCompRes[2] TLE8242_abTarCrntCompRes[3] TLE8242_abTarCrntCompRes[4] TLE8242_abTarCrntCompRes[5] TLE8242_abTarCrntCompRes[6] TLE8242_abTarCrntCompRes[7] TLE8242_abTarCrntCompRes[8] TLE8242_abTarCrntCompRes[9] TLE8242_af32AvgCrntMa TLE8242_af32AvgCrntMa[0] TLE8242_af32AvgCrntMa[10] TLE8242_af32AvgCrntMa[11] TLE8242_af32AvgCrntMa[12] TLE8242_af32AvgCrntMa[13] TLE8242_af32AvgCrntMa[14] TLE8242_af32AvgCrntMa[1] TLE8242_af32AvgCrntMa[2] TLE8242_af32AvgCrntMa[3] TLE8242_af32AvgCrntMa[4] TLE8242_af32AvgCrntMa[5] TLE8242_af32AvgCrntMa[6] TLE8242_af32AvgCrntMa[7] TLE8242_af32AvgCrntMa[8] TLE8242_af32AvgCrntMa[9] TLE8242_af32DitherAmplMa TLE8242_af32DitherAmplMa[0] TLE8242_af32DitherAmplMa[10] TLE8242_af32DitherAmplMa[11] TLE8242_af32DitherAmplMa[12] TLE8242_af32DitherAmplMa[13] TLE8242_af32DitherAmplMa[14] TLE8242_af32DitherAmplMa[1] TLE8242_af32DitherAmplMa[2] TLE8242_af32DitherAmplMa[3] TLE8242_af32DitherAmplMa[4] TLE8242_af32DitherAmplMa[5] TLE8242_af32DitherAmplMa[6] TLE8242_af32DitherAmplMa[7] TLE8242_af32DitherAmplMa[8] TLE8242_af32DitherAmplMa[9] TLE8242_af32DitherFrq TLE8242_af32DitherFrq[0] TLE8242_af32DitherFrq[10] TLE8242_af32DitherFrq[11] TLE8242_af32DitherFrq[12] TLE8242_af32DitherFrq[13] TLE8242_af32DitherFrq[14] TLE8242_af32DitherFrq[1] TLE8242_af32DitherFrq[2] TLE8242_af32DitherFrq[3] TLE8242_af32DitherFrq[4] TLE8242_af32DitherFrq[5] TLE8242_af32DitherFrq[6] TLE8242_af32DitherFrq[7] TLE8242_af32DitherFrq[8] TLE8242_af32DitherFrq[9] TLE8242_af32DutyCycle TLE8242_af32DutyCycle[0] TLE8242_af32DutyCycle[10] TLE8242_af32DutyCycle[11] TLE8242_af32DutyCycle[12] TLE8242_af32DutyCycle[13] TLE8242_af32DutyCycle[14] TLE8242_af32DutyCycle[1] TLE8242_af32DutyCycle[2] TLE8242_af32DutyCycle[3] TLE8242_af32DutyCycle[4] TLE8242_af32DutyCycle[5] TLE8242_af32DutyCycle[6] TLE8242_af32DutyCycle[7] TLE8242_af32DutyCycle[8] TLE8242_af32DutyCycle[9] TLE8242_af32MaxCnrtMa TLE8242_af32MaxCnrtMa[0] TLE8242_af32MaxCnrtMa[10] TLE8242_af32MaxCnrtMa[11] TLE8242_af32MaxCnrtMa[12] TLE8242_af32MaxCnrtMa[13] TLE8242_af32MaxCnrtMa[14] TLE8242_af32MaxCnrtMa[1] TLE8242_af32MaxCnrtMa[2] TLE8242_af32MaxCnrtMa[3] TLE8242_af32MaxCnrtMa[4] TLE8242_af32MaxCnrtMa[5] TLE8242_af32MaxCnrtMa[6] TLE8242_af32MaxCnrtMa[7] TLE8242_af32MaxCnrtMa[8] TLE8242_af32MaxCnrtMa[9] TLE8242_af32MinCnrtMa TLE8242_af32MinCnrtMa[0] TLE8242_af32MinCnrtMa[10] TLE8242_af32MinCnrtMa[11] TLE8242_af32MinCnrtMa[12] TLE8242_af32MinCnrtMa[13] TLE8242_af32MinCnrtMa[14] TLE8242_af32MinCnrtMa[1] TLE8242_af32MinCnrtMa[2] TLE8242_af32MinCnrtMa[3] TLE8242_af32MinCnrtMa[4] TLE8242_af32MinCnrtMa[5] TLE8242_af32MinCnrtMa[6] TLE8242_af32MinCnrtMa[7] TLE8242_af32MinCnrtMa[8] TLE8242_af32MinCnrtMa[9] TLE8242_af32TarCnrtAftTrimMa TLE8242_af32TarCnrtAftTrimMa[0] TLE8242_af32TarCnrtAftTrimMa[10] TLE8242_af32TarCnrtAftTrimMa[11] TLE8242_af32TarCnrtAftTrimMa[12] TLE8242_af32TarCnrtAftTrimMa[13] TLE8242_af32TarCnrtAftTrimMa[14] TLE8242_af32TarCnrtAftTrimMa[1] TLE8242_af32TarCnrtAftTrimMa[2] TLE8242_af32TarCnrtAftTrimMa[3] TLE8242_af32TarCnrtAftTrimMa[4] TLE8242_af32TarCnrtAftTrimMa[5] TLE8242_af32TarCnrtAftTrimMa[6] TLE8242_af32TarCnrtAftTrimMa[7] TLE8242_af32TarCnrtAftTrimMa[8] TLE8242_af32TarCnrtAftTrimMa[9] TLE8242_af32TarCnrtMa TLE8242_af32TarCnrtMa[0] TLE8242_af32TarCnrtMa[10] TLE8242_af32TarCnrtMa[11] TLE8242_af32TarCnrtMa[12] TLE8242_af32TarCnrtMa[13] TLE8242_af32TarCnrtMa[14] TLE8242_af32TarCnrtMa[1] TLE8242_af32TarCnrtMa[2] TLE8242_af32TarCnrtMa[3] TLE8242_af32TarCnrtMa[4] TLE8242_af32TarCnrtMa[5] TLE8242_af32TarCnrtMa[6] TLE8242_af32TarCnrtMa[7] TLE8242_af32TarCnrtMa[8] TLE8242_af32TarCnrtMa[9] TLE8242_af32TrimGrdtOfFuncGt TLE8242_af32TrimGrdtOfFuncGt[0] TLE8242_af32TrimGrdtOfFuncGt[10] TLE8242_af32TrimGrdtOfFuncGt[11] TLE8242_af32TrimGrdtOfFuncGt[12] TLE8242_af32TrimGrdtOfFuncGt[13] TLE8242_af32TrimGrdtOfFuncGt[14] TLE8242_af32TrimGrdtOfFuncGt[1] TLE8242_af32TrimGrdtOfFuncGt[2] TLE8242_af32TrimGrdtOfFuncGt[3] TLE8242_af32TrimGrdtOfFuncGt[4] TLE8242_af32TrimGrdtOfFuncGt[5] TLE8242_af32TrimGrdtOfFuncGt[6] TLE8242_af32TrimGrdtOfFuncGt[7] TLE8242_af32TrimGrdtOfFuncGt[8] TLE8242_af32TrimGrdtOfFuncGt[9] TLE8242_af32TrimGrdtOfFuncOt TLE8242_af32TrimGrdtOfFuncOt[0] TLE8242_af32TrimGrdtOfFuncOt[10] TLE8242_af32TrimGrdtOfFuncOt[11] TLE8242_af32TrimGrdtOfFuncOt[12] TLE8242_af32TrimGrdtOfFuncOt[13] TLE8242_af32TrimGrdtOfFuncOt[14] TLE8242_af32TrimGrdtOfFuncOt[1] TLE8242_af32TrimGrdtOfFuncOt[2] TLE8242_af32TrimGrdtOfFuncOt[3] TLE8242_af32TrimGrdtOfFuncOt[4] TLE8242_af32TrimGrdtOfFuncOt[5] TLE8242_af32TrimGrdtOfFuncOt[6] TLE8242_af32TrimGrdtOfFuncOt[7] TLE8242_af32TrimGrdtOfFuncOt[8] TLE8242_af32TrimGrdtOfFuncOt[9] TLE8242_af32TrimOffsOfFuncGt TLE8242_af32TrimOffsOfFuncGt[0] TLE8242_af32TrimOffsOfFuncGt[10] TLE8242_af32TrimOffsOfFuncGt[11] TLE8242_af32TrimOffsOfFuncGt[12] TLE8242_af32TrimOffsOfFuncGt[13] TLE8242_af32TrimOffsOfFuncGt[14] TLE8242_af32TrimOffsOfFuncGt[1] TLE8242_af32TrimOffsOfFuncGt[2] TLE8242_af32TrimOffsOfFuncGt[3] TLE8242_af32TrimOffsOfFuncGt[4] TLE8242_af32TrimOffsOfFuncGt[5] TLE8242_af32TrimOffsOfFuncGt[6] TLE8242_af32TrimOffsOfFuncGt[7] TLE8242_af32TrimOffsOfFuncGt[8] TLE8242_af32TrimOffsOfFuncGt[9] TLE8242_af32TrimOffsOfFuncOt TLE8242_af32TrimOffsOfFuncOt[0] TLE8242_af32TrimOffsOfFuncOt[10] TLE8242_af32TrimOffsOfFuncOt[11] TLE8242_af32TrimOffsOfFuncOt[12] TLE8242_af32TrimOffsOfFuncOt[13] TLE8242_af32TrimOffsOfFuncOt[14] TLE8242_af32TrimOffsOfFuncOt[1] TLE8242_af32TrimOffsOfFuncOt[2] TLE8242_af32TrimOffsOfFuncOt[3] TLE8242_af32TrimOffsOfFuncOt[4] TLE8242_af32TrimOffsOfFuncOt[5] TLE8242_af32TrimOffsOfFuncOt[6] TLE8242_af32TrimOffsOfFuncOt[7] TLE8242_af32TrimOffsOfFuncOt[8] TLE8242_af32TrimOffsOfFuncOt[9] TLE8242_au8CrntReadChNr TLE8242_au8CrntReadChNr[0] TLE8242_au8CrntReadChNr[1] TLE8242_au8CrntReadCnt TLE8242_au8CrntReadCnt[0][0] TLE8242_au8CrntReadCnt[0][1] TLE8242_au8CrntReadCnt[0][2] TLE8242_au8CrntReadCnt[0][3] TLE8242_au8CrntReadCnt[0][4] TLE8242_au8CrntReadCnt[0][5] TLE8242_au8CrntReadCnt[0][6] TLE8242_au8CrntReadCnt[0][7] TLE8242_au8CrntReadCnt[1][0] TLE8242_au8CrntReadCnt[1][1] TLE8242_au8CrntReadCnt[1][2] TLE8242_au8CrntReadCnt[1][3] TLE8242_au8CrntReadCnt[1][4] TLE8242_au8CrntReadCnt[1][5] TLE8242_au8CrntReadCnt[1][6] TLE8242_au8CrntReadCnt[1][7] TLE8242_au8CrntVld TLE8242_au8CrntVld[0][0] TLE8242_au8CrntVld[0][1] TLE8242_au8CrntVld[1][0] TLE8242_au8CrntVld[1][1] TLE8242_au8FltSts TLE8242_au8FltSts[0][0] TLE8242_au8FltSts[0][1] TLE8242_au8FltSts[0][2] TLE8242_au8FltSts[0][3] TLE8242_au8FltSts[0][4] TLE8242_au8FltSts[0][5] TLE8242_au8FltSts[10][0] TLE8242_au8FltSts[10][1] TLE8242_au8FltSts[10][2] TLE8242_au8FltSts[10][3] TLE8242_au8FltSts[10][4] TLE8242_au8FltSts[10][5] TLE8242_au8FltSts[11][0] TLE8242_au8FltSts[11][1] TLE8242_au8FltSts[11][2] TLE8242_au8FltSts[11][3] TLE8242_au8FltSts[11][4] TLE8242_au8FltSts[11][5] TLE8242_au8FltSts[12][0] TLE8242_au8FltSts[12][1] TLE8242_au8FltSts[12][2] TLE8242_au8FltSts[12][3] TLE8242_au8FltSts[12][4] TLE8242_au8FltSts[12][5] TLE8242_au8FltSts[13][0] TLE8242_au8FltSts[13][1] TLE8242_au8FltSts[13][2] TLE8242_au8FltSts[13][3] TLE8242_au8FltSts[13][4] TLE8242_au8FltSts[13][5] TLE8242_au8FltSts[14][0] TLE8242_au8FltSts[14][1] TLE8242_au8FltSts[14][2] TLE8242_au8FltSts[14][3] TLE8242_au8FltSts[14][4] TLE8242_au8FltSts[14][5] TLE8242_au8FltSts[1][0] TLE8242_au8FltSts[1][1] TLE8242_au8FltSts[1][2] TLE8242_au8FltSts[1][3] TLE8242_au8FltSts[1][4] TLE8242_au8FltSts[1][5] TLE8242_au8FltSts[2][0] TLE8242_au8FltSts[2][1] TLE8242_au8FltSts[2][2] TLE8242_au8FltSts[2][3] TLE8242_au8FltSts[2][4] TLE8242_au8FltSts[2][5] TLE8242_au8FltSts[3][0] TLE8242_au8FltSts[3][1] TLE8242_au8FltSts[3][2] TLE8242_au8FltSts[3][3] TLE8242_au8FltSts[3][4] TLE8242_au8FltSts[3][5] TLE8242_au8FltSts[4][0] TLE8242_au8FltSts[4][1] TLE8242_au8FltSts[4][2] TLE8242_au8FltSts[4][3] TLE8242_au8FltSts[4][4] TLE8242_au8FltSts[4][5] TLE8242_au8FltSts[5][0] TLE8242_au8FltSts[5][1] TLE8242_au8FltSts[5][2] TLE8242_au8FltSts[5][3] TLE8242_au8FltSts[5][4] TLE8242_au8FltSts[5][5] TLE8242_au8FltSts[6][0] TLE8242_au8FltSts[6][1] TLE8242_au8FltSts[6][2] TLE8242_au8FltSts[6][3] TLE8242_au8FltSts[6][4] TLE8242_au8FltSts[6][5] TLE8242_au8FltSts[7][0] TLE8242_au8FltSts[7][1] TLE8242_au8FltSts[7][2] TLE8242_au8FltSts[7][3] TLE8242_au8FltSts[7][4] TLE8242_au8FltSts[7][5] TLE8242_au8FltSts[8][0] TLE8242_au8FltSts[8][1] TLE8242_au8FltSts[8][2] TLE8242_au8FltSts[8][3] TLE8242_au8FltSts[8][4] TLE8242_au8FltSts[8][5] TLE8242_au8FltSts[9][0] TLE8242_au8FltSts[9][1] TLE8242_au8FltSts[9][2] TLE8242_au8FltSts[9][3] TLE8242_au8FltSts[9][4] TLE8242_au8FltSts[9][5] TLE8242_au8OpenLoadLastVal TLE8242_au8OpenLoadLastVal[0] TLE8242_au8OpenLoadLastVal[10] TLE8242_au8OpenLoadLastVal[11] TLE8242_au8OpenLoadLastVal[12] TLE8242_au8OpenLoadLastVal[13] TLE8242_au8OpenLoadLastVal[14] TLE8242_au8OpenLoadLastVal[1] TLE8242_au8OpenLoadLastVal[2] TLE8242_au8OpenLoadLastVal[3] TLE8242_au8OpenLoadLastVal[4] TLE8242_au8OpenLoadLastVal[5] TLE8242_au8OpenLoadLastVal[6] TLE8242_au8OpenLoadLastVal[7] TLE8242_au8OpenLoadLastVal[8] TLE8242_au8OpenLoadLastVal[9] TLE8242_au8OpenLoadMaxReadCnt TLE8242_au8OpenLoadMaxReadCnt[0] TLE8242_au8OpenLoadMaxReadCnt[10] TLE8242_au8OpenLoadMaxReadCnt[11] TLE8242_au8OpenLoadMaxReadCnt[12] TLE8242_au8OpenLoadMaxReadCnt[13] TLE8242_au8OpenLoadMaxReadCnt[14] TLE8242_au8OpenLoadMaxReadCnt[1] TLE8242_au8OpenLoadMaxReadCnt[2] TLE8242_au8OpenLoadMaxReadCnt[3] TLE8242_au8OpenLoadMaxReadCnt[4] TLE8242_au8OpenLoadMaxReadCnt[5] TLE8242_au8OpenLoadMaxReadCnt[6] TLE8242_au8OpenLoadMaxReadCnt[7] TLE8242_au8OpenLoadMaxReadCnt[8] TLE8242_au8OpenLoadMaxReadCnt[9] TLE8242_au8OpenLoadReadCnt TLE8242_au8OpenLoadReadCnt[0] TLE8242_au8OpenLoadReadCnt[10] TLE8242_au8OpenLoadReadCnt[11] TLE8242_au8OpenLoadReadCnt[12] TLE8242_au8OpenLoadReadCnt[13] TLE8242_au8OpenLoadReadCnt[14] TLE8242_au8OpenLoadReadCnt[1] TLE8242_au8OpenLoadReadCnt[2] TLE8242_au8OpenLoadReadCnt[3] TLE8242_au8OpenLoadReadCnt[4] TLE8242_au8OpenLoadReadCnt[5] TLE8242_au8OpenLoadReadCnt[6] TLE8242_au8OpenLoadReadCnt[7] TLE8242_au8OpenLoadReadCnt[8] TLE8242_au8OpenLoadReadCnt[9] TLE8242_au8OpenLoadRealVal TLE8242_au8OpenLoadRealVal[0] TLE8242_au8OpenLoadRealVal[10] TLE8242_au8OpenLoadRealVal[11] TLE8242_au8OpenLoadRealVal[12] TLE8242_au8OpenLoadRealVal[13] TLE8242_au8OpenLoadRealVal[14] TLE8242_au8OpenLoadRealVal[1] TLE8242_au8OpenLoadRealVal[2] TLE8242_au8OpenLoadRealVal[3] TLE8242_au8OpenLoadRealVal[4] TLE8242_au8OpenLoadRealVal[5] TLE8242_au8OpenLoadRealVal[6] TLE8242_au8OpenLoadRealVal[7] TLE8242_au8OpenLoadRealVal[8] TLE8242_au8OpenLoadRealVal[9] TLE8242_au8PwmOffs TLE8242_au8PwmOffs[0] TLE8242_au8PwmOffs[10] TLE8242_au8PwmOffs[11] TLE8242_au8PwmOffs[12] TLE8242_au8PwmOffs[13] TLE8242_au8PwmOffs[14] TLE8242_au8PwmOffs[1] TLE8242_au8PwmOffs[2] TLE8242_au8PwmOffs[3] TLE8242_au8PwmOffs[4] TLE8242_au8PwmOffs[5] TLE8242_au8PwmOffs[6] TLE8242_au8PwmOffs[7] TLE8242_au8PwmOffs[8] TLE8242_au8PwmOffs[9] TLE8242_u8ErrMsgRevCnt /end OUT_MEASUREMENT
/end FUNCTION
/begin FUNCTION TLF35584 ""
 /begin OUT_MEASUREMENT TLF35584_audtRegSt TLF35584_audtRegSt[0] TLF35584_audtRegSt[10] TLF35584_audtRegSt[11] TLF35584_audtRegSt[12] TLF35584_audtRegSt[1] TLF35584_audtRegSt[2] TLF35584_audtRegSt[3] TLF35584_audtRegSt[4] TLF35584_audtRegSt[5] TLF35584_audtRegSt[6] TLF35584_audtRegSt[7] TLF35584_audtRegSt[8] TLF35584_audtRegSt[9] /end OUT_MEASUREMENT
/end FUNCTION
/begin FUNCTION TSTVAR ""
 /begin OUT_MEASUREMENT TST_DET_u16ModuleId TST_DET_u16NbOfRecordToAdd TST_DET_u8ApiId TST_DET_u8ErrorId TST_DET_u8InstanceId /end OUT_MEASUREMENT
/end FUNCTION
/begin GROUP Acquisitions "Acquisitions_GROUP" ROOT /begin FUNCTION_LIST IOHAL /end FUNCTION_LIST /end GROUP
/begin GROUP Application "Application_GROUP" ROOT /begin FUNCTION_LIST BTT6020 BTT60X0 J1939IF Lvl2RamCrc SCU SWTST TLE8242 /end FUNCTION_LIST /end GROUP
/begin GROUP BSW "BSW_GROUP" ROOT
 /begin FUNCTION_LIST ADXL313 BSW BTT60X0 DemJ1939Wrapper Diagnostic RSTSRV SpdSnsrDirDetn TEMP /end FUNCTION_LIST
/end GROUP
/begin GROUP BTT60X0 "BTT60X0_GROUP" ROOT /begin FUNCTION_LIST BTT60X0 /end FUNCTION_LIST /end GROUP
/begin GROUP Commandes "Commandes_GROUP" ROOT /begin FUNCTION_LIST PWD /end FUNCTION_LIST /end GROUP
/begin GROUP DEVHAL "DEVHAL_GROUP" ROOT /begin FUNCTION_LIST DEVHAL /end FUNCTION_LIST /end GROUP
/begin GROUP Development_z "Development_z_GROUP" ROOT /begin FUNCTION_LIST DEVHAL SPY /end FUNCTION_LIST /end GROUP
/begin GROUP Divers "Divers_GROUP" ROOT /begin FUNCTION_LIST DEVHAL SAFETSTM SAFEWDGM /end FUNCTION_LIST /end GROUP
/begin GROUP MCAL "MCAL_GROUP" ROOT /begin FUNCTION_LIST PWD /end FUNCTION_LIST /end GROUP
/begin GROUP Main "Main_GROUP" ROOT /begin FUNCTION_LIST MAIN SPY /end FUNCTION_LIST /end GROUP
/begin GROUP Miscellaneous "Miscellaneous_GROUP" ROOT /begin FUNCTION_LIST RTMCLD /end FUNCTION_LIST /end GROUP
/begin GROUP NONE_ "NONE__GROUP" ROOT
 /begin FUNCTION_LIST ADXL313 BSW BTT6020 BTT60X0 DemJ1939Wrapper Diagnostic J1939IF MAIN PWD RSTSRV RTMTSK SCU SWTST SpdSnsrDirDetn TEMP TLE8242 /end FUNCTION_LIST
/end GROUP
/begin GROUP Noyau "Noyau_GROUP" ROOT /begin FUNCTION_LIST RTMTSK /end FUNCTION_LIST /end GROUP
/begin GROUP NvM "NvM_GROUP" ROOT /begin FUNCTION_LIST BSW /end FUNCTION_LIST /end GROUP
/begin GROUP RSTSRV "RSTSRV_GROUP" ROOT /begin FUNCTION_LIST RSTSRV /end FUNCTION_LIST /end GROUP
/begin GROUP STUB "STUB_GROUP" ROOT /begin FUNCTION_LIST STUB /end FUNCTION_LIST /end GROUP
/begin GROUP Safety "Safety_GROUP" ROOT /begin FUNCTION_LIST SAFEDGM /end FUNCTION_LIST /end GROUP
/begin GROUP TLE8242 "TLE8242_GROUP" ROOT /begin FUNCTION_LIST TLE8242 TLF35584 /end FUNCTION_LIST /end GROUP
/begin GROUP TST "TST_GROUP" ROOT /begin FUNCTION_LIST TSTVAR /end FUNCTION_LIST /end GROUP
/end MODULE
/end PROJECT
