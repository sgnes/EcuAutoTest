ASAP2_VERSION 1 70
/begin PROJECT TEST_PROJECT "TEST_PROJECT"
/begin HEADER "TEST_PROJECT" PROJECT_NO D0 VERSION "3095.02" /end HEADER
/begin MODULE TEST_PROJECT "TestSupplier"
/begin MOD_COMMON "" DEPOSIT ABSOLUTE BYTE_ORDER MSB_LAST ALIGNMENT_BYTE 1 ALIGNMENT_WORD 2 ALIGNMENT_LONG 4 ALIGNMENT_INT64 1 ALIGNMENT_FLOAT32_IEEE 4 ALIGNMENT_FLOAT64_IEEE 8 /end MOD_COMMON
/begin RECORD_LAYOUT DATA_RECORD_UBYTE FNC_VALUES 1 UBYTE ROW_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT DATA_RECORD_UWORD FNC_VALUES 1 UWORD ROW_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT DATA_RECORD_ULONG FNC_VALUES 1 ULONG ROW_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT AXIS_PTS_X_SWORD_VEMS AXIS_PTS_X 1 SWORD INDEX_INCR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT AXIS_PTS_X_ULONG_VEMS AXIS_PTS_X 1 ULONG INDEX_INCR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT AXIS_PTS_X_SLONG_VEMS AXIS_PTS_X 1 SLONG INDEX_INCR DIRECT /end RECORD_LAYOUT
/begin CHARACTERISTIC RSTSRV_ku16ConsecutiveRstMaxNbC "RSTSRV_ku16ConsecutiveRstMaxNbC" VALUE 0x80028A34 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC RTMTSK_ku8TaskId "RTMTSK_ku8TaskId" VALUE 0x80028A3F DATA_RECORD_UBYTE 255 I_5 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC SCU_ku16MaxDieTempThrd "Temperature max threshold" VALUE 0x80028A2E DATA_RECORD_UWORD 30767.60563 F_0v4694835681_m284v9765258216_24 -284.9765258 30482.62911 /end CHARACTERISTIC
/begin CHARACTERISTIC SCU_ku16MinDieTempThrd "Temperature min threshold" VALUE 0x80028A2C DATA_RECORD_UWORD 30767.60563 F_0v4694835681_m284v9765258216_24 -284.9765258 30482.62911 /end CHARACTERISTIC
/begin CHARACTERISTIC STUB_ku32NvmWriteTimeOut "STUB_ku32NvmWriteTimeOut" VALUE 0x80028A38 DATA_RECORD_ULONG 4294967295 F_1_p0_25 0 4294967295 /end CHARACTERISTIC
/begin MEASUREMENT RSTSRV_bSWResetDetected "RSTSRV_bSWResetDetected" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x6000EDF1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT RSTSRV_bSWResetDoneByPerformReset "RSTSRV_bSWResetDoneByPerformReset" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x6000EDF0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT RSTSRV_enuRstSrc "Source of the reset defined during startup" UWORD RSTSRV_enuRstSrc_conv 1 2 0 255 ECU_ADDRESS 0x6000EDF4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT RSTSRV_u16ConsecutiveRstCtr "RSTSRV_u16ConsecutiveRstCtr" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x6000FEFE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT RSTSRV_u16HotResetCtr "RSTSRV_u16HotResetCtr" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x6000FEFC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT RSTSRV_u16TimeAfterInit "RSTSRV_u16TimeAfterInit" UWORD F_100_p0_22 1 2 0 6553500 ECU_ADDRESS 0x6000EDF2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT RSTSRV_u32ResetReason "RSTSRV_u32ResetReason" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000EDF8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT RTMCLD_u16MeasurementPeriodCounter "RTMCLD_u16MeasurementPeriodCounter" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60000DD0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT RTMCLD_u32IdleClock "RTMCLD_u32IdleClock" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60010D24 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT RTMCLD_u32Load "RTMCLD_u32Load" ULONG F_m0v0000045_p100_23 1 2 -19227.35283 100 ECU_ADDRESS 0x60000DD8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT RTMCLD_u32PrevIdleClock "RTMCLD_u32PrevIdleClock" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60000DD4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT RTMTSK_u32TaskDuration "RTMTSK_u32TaskDuration" ULONG F_0v01_p0_4 1 2 0 42949672.95 ECU_ADDRESS 0x60000DE4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT RTMTSK_u32TaskStartTime "RTMTSK_u32TaskStartTime" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60000DE0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT RTMTSK_u8TaskId "RTMTSK_u8TaskId" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60000DDC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEDGM_au32ErrsLedToRstPerGrp "SAFEDGM_au32ErrsLedToRstPerGrp" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 9 1 1 ECU_ADDRESS 0x6000FF04 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEDGM_au32ErrsLedToRstPerGrp[0] "SAFEDGM_au32ErrsLedToRstPerGrp[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000FF04 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEDGM_au32ErrsLedToRstPerGrp[1] "SAFEDGM_au32ErrsLedToRstPerGrp[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000FF08 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEDGM_au32ErrsLedToRstPerGrp[2] "SAFEDGM_au32ErrsLedToRstPerGrp[2]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000FF0C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEDGM_au32ErrsLedToRstPerGrp[3] "SAFEDGM_au32ErrsLedToRstPerGrp[3]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000FF10 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEDGM_au32ErrsLedToRstPerGrp[4] "SAFEDGM_au32ErrsLedToRstPerGrp[4]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000FF14 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEDGM_au32ErrsLedToRstPerGrp[5] "SAFEDGM_au32ErrsLedToRstPerGrp[5]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000FF18 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEDGM_au32ErrsLedToRstPerGrp[6] "SAFEDGM_au32ErrsLedToRstPerGrp[6]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000FF1C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEDGM_au32ErrsLedToRstPerGrp[7] "SAFEDGM_au32ErrsLedToRstPerGrp[7]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000FF20 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEDGM_au32ErrsLedToRstPerGrp[8] "SAFEDGM_au32ErrsLedToRstPerGrp[8]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000FF24 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEDGM_au32ErrsPerGrp "SAFEDGM_au32ErrsPerGrp" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 9 1 1 ECU_ADDRESS 0x6000EED8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEDGM_au32ErrsPerGrp[0] "SAFEDGM_au32ErrsPerGrp[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000EED8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEDGM_au32ErrsPerGrp[1] "SAFEDGM_au32ErrsPerGrp[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000EEDC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEDGM_au32ErrsPerGrp[2] "SAFEDGM_au32ErrsPerGrp[2]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000EEE0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEDGM_au32ErrsPerGrp[3] "SAFEDGM_au32ErrsPerGrp[3]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000EEE4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEDGM_au32ErrsPerGrp[4] "SAFEDGM_au32ErrsPerGrp[4]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000EEE8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEDGM_au32ErrsPerGrp[5] "SAFEDGM_au32ErrsPerGrp[5]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000EEEC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEDGM_au32ErrsPerGrp[6] "SAFEDGM_au32ErrsPerGrp[6]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000EEF0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEDGM_au32ErrsPerGrp[7] "SAFEDGM_au32ErrsPerGrp[7]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000EEF4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEDGM_au32ErrsPerGrp[8] "SAFEDGM_au32ErrsPerGrp[8]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000EEF8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_astrStsLog[0].udtSlFlsTstEccErrPatChk "SAFETSTM_astrStsLog[0].udtSlFlsTstEccErrPatChk" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60006D18 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_astrStsLog[0].udtSlInit "SAFETSTM_astrStsLog[0].udtSlInit" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60006D1A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_astrStsLog[0].udtSlPreInit "SAFETSTM_astrStsLog[0].udtSlPreInit" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60006D19 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_astrStsLog[0].udtSlRun "SAFETSTM_astrStsLog[0].udtSlRun" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60006D1B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_astrStsLog[0].udtSlTstsPreRun "SAFETSTM_astrStsLog[0].udtSlTstsPreRun" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60006D1C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_astrStsLog[0].udtSlTstsRun "SAFETSTM_astrStsLog[0].udtSlTstsRun" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60006D1D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_astrStsLog[0].udtUsrTstsPreRun "SAFETSTM_astrStsLog[0].udtUsrTstsPreRun" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60006D1E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_astrStsLog[1].udtSlFlsTstEccErrPatChk "SAFETSTM_astrStsLog[1].udtSlFlsTstEccErrPatChk" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60006D20 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_astrStsLog[1].udtSlInit "SAFETSTM_astrStsLog[1].udtSlInit" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60006D22 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_astrStsLog[1].udtSlPreInit "SAFETSTM_astrStsLog[1].udtSlPreInit" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60006D21 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_astrStsLog[1].udtSlRun "SAFETSTM_astrStsLog[1].udtSlRun" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60006D23 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_astrStsLog[1].udtSlTstsPreRun "SAFETSTM_astrStsLog[1].udtSlTstsPreRun" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60006D24 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_astrStsLog[1].udtSlTstsRun "SAFETSTM_astrStsLog[1].udtSlTstsRun" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60006D25 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_astrStsLog[1].udtUsrTstsPreRun "SAFETSTM_astrStsLog[1].udtUsrTstsPreRun" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60006D26 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_astrStsLog[2].udtSlFlsTstEccErrPatChk "SAFETSTM_astrStsLog[2].udtSlFlsTstEccErrPatChk" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60006D28 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_astrStsLog[2].udtSlInit "SAFETSTM_astrStsLog[2].udtSlInit" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60006D2A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_astrStsLog[2].udtSlPreInit "SAFETSTM_astrStsLog[2].udtSlPreInit" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60006D29 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_astrStsLog[2].udtSlRun "SAFETSTM_astrStsLog[2].udtSlRun" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60006D2B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_astrStsLog[2].udtSlTstsPreRun "SAFETSTM_astrStsLog[2].udtSlTstsPreRun" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60006D2C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_astrStsLog[2].udtSlTstsRun "SAFETSTM_astrStsLog[2].udtSlTstsRun" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60006D2D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_astrStsLog[2].udtUsrTstsPreRun "SAFETSTM_astrStsLog[2].udtUsrTstsPreRun" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60006D2E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore0 "Results of SafeTlib PreRun tests. In memory, it is a 2D table [MCAL_NO_OF_CORES][TH_TOTAL_TESTS]." ULONG I_5 1 2 0 4294967295 MATRIX_DIM 1 12 1 ECU_ADDRESS 0x6000F0AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore0[0] "SAFETSTM_audtSlPreRunTstsRslt[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000F0AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore0[10] "SAFETSTM_audtSlPreRunTstsRslt[10]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000F0D4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore0[11] "SAFETSTM_audtSlPreRunTstsRslt[11]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000F0D8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore0[1] "SAFETSTM_audtSlPreRunTstsRslt[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000F0B0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore0[2] "SAFETSTM_audtSlPreRunTstsRslt[2]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000F0B4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore0[3] "SAFETSTM_audtSlPreRunTstsRslt[3]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000F0B8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore0[4] "SAFETSTM_audtSlPreRunTstsRslt[4]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000F0BC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore0[5] "SAFETSTM_audtSlPreRunTstsRslt[5]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000F0C0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore0[6] "SAFETSTM_audtSlPreRunTstsRslt[6]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000F0C4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore0[7] "SAFETSTM_audtSlPreRunTstsRslt[7]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000F0C8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore0[8] "SAFETSTM_audtSlPreRunTstsRslt[8]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000F0CC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore0[9] "SAFETSTM_audtSlPreRunTstsRslt[9]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000F0D0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore1 "Results of SafeTlib PreRun tests. In memory, it is a 2D table [MCAL_NO_OF_CORES][TH_TOTAL_TESTS]." ULONG I_5 1 2 0 4294967295 MATRIX_DIM 1 12 1 ECU_ADDRESS 0x6000F0DC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore1[0] "SAFETSTM_audtSlPreRunTstsRslt[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000F0DC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore1[10] "SAFETSTM_audtSlPreRunTstsRslt[10]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000F104 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore1[11] "SAFETSTM_audtSlPreRunTstsRslt[11]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000F108 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore1[1] "SAFETSTM_audtSlPreRunTstsRslt[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000F0E0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore1[2] "SAFETSTM_audtSlPreRunTstsRslt[2]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000F0E4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore1[3] "SAFETSTM_audtSlPreRunTstsRslt[3]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000F0E8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore1[4] "SAFETSTM_audtSlPreRunTstsRslt[4]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000F0EC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore1[5] "SAFETSTM_audtSlPreRunTstsRslt[5]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000F0F0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore1[6] "SAFETSTM_audtSlPreRunTstsRslt[6]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000F0F4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore1[7] "SAFETSTM_audtSlPreRunTstsRslt[7]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000F0F8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore1[8] "SAFETSTM_audtSlPreRunTstsRslt[8]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000F0FC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore1[9] "SAFETSTM_audtSlPreRunTstsRslt[9]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000F100 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore2 "Results of SafeTlib PreRun tests. In memory, it is a 2D table [MCAL_NO_OF_CORES][TH_TOTAL_TESTS]." ULONG I_5 1 2 0 4294967295 MATRIX_DIM 1 12 1 ECU_ADDRESS 0x6000F10C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore2[0] "SAFETSTM_audtSlPreRunTstsRslt[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000F10C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore2[10] "SAFETSTM_audtSlPreRunTstsRslt[10]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000F134 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore2[11] "SAFETSTM_audtSlPreRunTstsRslt[11]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000F138 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore2[1] "SAFETSTM_audtSlPreRunTstsRslt[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000F110 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore2[2] "SAFETSTM_audtSlPreRunTstsRslt[2]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000F114 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore2[3] "SAFETSTM_audtSlPreRunTstsRslt[3]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000F118 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore2[4] "SAFETSTM_audtSlPreRunTstsRslt[4]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000F11C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore2[5] "SAFETSTM_audtSlPreRunTstsRslt[5]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000F120 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore2[6] "SAFETSTM_audtSlPreRunTstsRslt[6]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000F124 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore2[7] "SAFETSTM_audtSlPreRunTstsRslt[7]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000F128 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore2[8] "SAFETSTM_audtSlPreRunTstsRslt[8]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000F12C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFETSTM_audtSlPreRunTstsRsltCore2[9] "SAFETSTM_audtSlPreRunTstsRslt[9]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000F130 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_bDeinitRequest "SAFEWDGM_bDeinitRequest" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x6000897B /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_bDisableRequest "SAFEWDGM_bDisableRequest" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x6000897A /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_bEnableRequest "SAFEWDGM_bEnableRequest" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x6000046D /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_bInitRequest "SAFEWDGM_bInitRequest" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x6000046C /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_bReady "SAFEWDGM_bReady" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x6000046B /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_bResetRequest "SAFEWDGM_bResetRequest" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60008979 /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_bSleepRequest "SAFEWDGM_bSleepRequest" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60008978 /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_bValidDeinitRequest "SAFEWDGM_bValidDeinitRequest" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x6000046A /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_bValidDisableRequest "SAFEWDGM_bValidDisableRequest" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60000469 /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_bValidEnableRequest "SAFEWDGM_bValidEnableRequest" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60000468 /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_bValidInitRequest "SAFEWDGM_bValidInitRequest" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60000467 /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_bValidResetRequest "SAFEWDGM_bValidResetRequest" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60000466 /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_bValidSleepRequest "SAFEWDGM_bValidSleepRequest" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60000465 /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_enuFailState "SAFEWDGM_enuFailState" UWORD SAFEWDGM_enuFailState_conv 1 2 0 12 ECU_ADDRESS 0x600004DA /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_enuInactiveState "SAFEWDGM_enuInactiveState" UWORD SAFEWDGM_enuInactiveState_conv 1 2 0 14 ECU_ADDRESS 0x600004D8 /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_enuInitState "SAFEWDGM_enuInitState" UWORD SAFEWDGM_enuInitState_conv 1 2 0 5 ECU_ADDRESS 0x600004D6 /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_enuMainPhase "SAFEWDGM_enuMainPhase" UWORD SAFEWDGM_enuMainPhase_conv 1 2 0 3 ECU_ADDRESS 0x600004D4 /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_enuRunState "SAFEWDGM_enuRunState" UWORD SAFEWDGM_enuRunState_conv 1 2 0 1 ECU_ADDRESS 0x600004D2 /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_u8ActivateAttemptCntr "SAFEWDGM_u8ActivateAttemptCntr" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60000464 /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_u8ActivateTimeoutCntr "SAFEWDGM_u8ActivateTimeoutCntr" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60000463 /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_u8DeactivateAttemptCntr "SAFEWDGM_u8DeactivateAttemptCntr" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60000462 /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_u8DeactivateTimeoutCntr "SAFEWDGM_u8DeactivateTimeoutCntr" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60000461 /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_u8InitAttemptCntr "SAFEWDGM_u8InitAttemptCntr" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60000460 /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_u8InitTimeoutCntr "SAFEWDGM_u8InitTimeoutCntr" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000045F /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_u8RuntimeSlotIdx "SAFEWDGM_u8RuntimeSlotIdx" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000045E /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_u8State "ACTIVATING(0)/ACTIVE(1)/ACTIVE_FAILED(2)/DEACTIVATING(3)/ASLEEP(4)/DISABLED(5)/DEINITIALIZED(6)/FAILED(7)" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000045D /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_u8WdgErrIncCntr "SAFEWDGM_u8WdgErrIncCntr" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000045C /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_u8WdgNewErrCntr "SAFEWDGM_u8WdgNewErrCntr" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600004D1 /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_u8WdgState "SAFEWDGM_u8WdgState" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600004D0 /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[00].ReqCmd "SAFEWDGM_udtUserCmd[00].ReqCmd" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60000476 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[00].UserData "SAFEWDGM_udtUserCmd[00].UserData" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60000477 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[01].ReqCmd "SAFEWDGM_udtUserCmd[01].ReqCmd" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60000478 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[01].UserData "SAFEWDGM_udtUserCmd[01].UserData" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60000479 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[02].ReqCmd "SAFEWDGM_udtUserCmd[02].ReqCmd" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000047A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[02].UserData "SAFEWDGM_udtUserCmd[02].UserData" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000047B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[03].ReqCmd "SAFEWDGM_udtUserCmd[03].ReqCmd" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000047C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[03].UserData "SAFEWDGM_udtUserCmd[03].UserData" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000047D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[04].ReqCmd "SAFEWDGM_udtUserCmd[04].ReqCmd" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000047E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[04].UserData "SAFEWDGM_udtUserCmd[04].UserData" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000047F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[05].ReqCmd "SAFEWDGM_udtUserCmd[05].ReqCmd" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60000480 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[05].UserData "SAFEWDGM_udtUserCmd[05].UserData" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60000481 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[06].ReqCmd "SAFEWDGM_udtUserCmd[06].ReqCmd" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60000482 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[06].UserData "SAFEWDGM_udtUserCmd[06].UserData" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60000483 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[07].ReqCmd "SAFEWDGM_udtUserCmd[07].ReqCmd" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60000484 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[07].UserData "SAFEWDGM_udtUserCmd[07].UserData" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60000485 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[08].ReqCmd "SAFEWDGM_udtUserCmd[08].ReqCmd" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60000486 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[08].UserData "SAFEWDGM_udtUserCmd[08].UserData" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60000487 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[09].ReqCmd "SAFEWDGM_udtUserCmd[09].ReqCmd" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60000488 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[09].UserData "SAFEWDGM_udtUserCmd[09].UserData" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60000489 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[10].ReqCmd "SAFEWDGM_udtUserCmd[10].ReqCmd" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000048A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[10].UserData "SAFEWDGM_udtUserCmd[10].UserData" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000048B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[11].ReqCmd "SAFEWDGM_udtUserCmd[11].ReqCmd" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000048C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[11].UserData "SAFEWDGM_udtUserCmd[11].UserData" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000048D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[12].ReqCmd "SAFEWDGM_udtUserCmd[12].ReqCmd" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000048E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[12].UserData "SAFEWDGM_udtUserCmd[12].UserData" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000048F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[13].ReqCmd "SAFEWDGM_udtUserCmd[13].ReqCmd" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60000490 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[13].UserData "SAFEWDGM_udtUserCmd[13].UserData" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60000491 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[14].ReqCmd "SAFEWDGM_udtUserCmd[14].ReqCmd" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60000492 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[14].UserData "SAFEWDGM_udtUserCmd[14].UserData" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60000493 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[15].ReqCmd "SAFEWDGM_udtUserCmd[15].ReqCmd" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60000494 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[15].UserData "SAFEWDGM_udtUserCmd[15].UserData" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60000495 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[16].ReqCmd "SAFEWDGM_udtUserCmd[16].ReqCmd" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60000496 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[16].UserData "SAFEWDGM_udtUserCmd[16].UserData" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60000497 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[17].ReqCmd "SAFEWDGM_udtUserCmd[17].ReqCmd" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60000498 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[17].UserData "SAFEWDGM_udtUserCmd[17].UserData" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60000499 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[18].ReqCmd "SAFEWDGM_udtUserCmd[18].ReqCmd" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000049A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[18].UserData "SAFEWDGM_udtUserCmd[18].UserData" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000049B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[19].ReqCmd "SAFEWDGM_udtUserCmd[19].ReqCmd" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000049C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[19].UserData "SAFEWDGM_udtUserCmd[19].UserData" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000049D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[20].ReqCmd "SAFEWDGM_udtUserCmd[20].ReqCmd" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000049E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[20].UserData "SAFEWDGM_udtUserCmd[20].UserData" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000049F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[21].ReqCmd "SAFEWDGM_udtUserCmd[21].ReqCmd" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600004A0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[21].UserData "SAFEWDGM_udtUserCmd[21].UserData" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600004A1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[22].ReqCmd "SAFEWDGM_udtUserCmd[22].ReqCmd" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600004A2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[22].UserData "SAFEWDGM_udtUserCmd[22].UserData" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600004A3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[23].ReqCmd "SAFEWDGM_udtUserCmd[23].ReqCmd" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600004A4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[23].UserData "SAFEWDGM_udtUserCmd[23].UserData" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600004A5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[24].ReqCmd "SAFEWDGM_udtUserCmd[24].ReqCmd" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600004A6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SAFEWDGM_udtUserCmd[24].UserData "SAFEWDGM_udtUserCmd[24].UserData" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600004A7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SCU_bDieFirstTemp "Temp limits initialized" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60000D06 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SCU_u16DieTemp "SCU_u16DieTemp" UWORD F_0v4694835681_m284v9765258216_24 1 2 -284.9765258 30482.62911 ECU_ADDRESS 0x60000D04 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SPY_bBufFull "SPY_bBufFull" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60000DCC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SPY_u16DaqListFirstElmIdx "SPY_u16DaqListFirstElmIdx" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60000DCA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SPY_u16NrOfElmsToTx "SPY_u16NrOfElmsToTx" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60000DC8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SPY_u16PreTrigSmplIdx "SPY_u16PreTrigSmplIdx" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60000DC6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SPY_u16RmngSmplIdx "SPY_u16RmngSmplIdx" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60000DC4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SPY_u16SmplIdx "SPY_u16SmplIdx" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60000DC2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SPY_u16TrigSmplIdx "SPY_u16TrigSmplIdx" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60000DC0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au32SftyCurSafeSts "SWTST_au32SftyCurSafeSts" ULONG Id_0x00 1 2 0 2147483648 MATRIX_DIM 8 1 1 ECU_ADDRESS 0x60014A2C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au32SftyCurSafeSts[0] "SWTST_au32SftyCurSafeSts[0]" ULONG Id_0x00 1 2 0 2147483648 ECU_ADDRESS 0x60014A2C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au32SftyCurSafeSts[1] "SWTST_au32SftyCurSafeSts[1]" ULONG Id_0x00 1 2 0 2147483648 ECU_ADDRESS 0x60014A30 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au32SftyCurSafeSts[2] "SWTST_au32SftyCurSafeSts[2]" ULONG Id_0x00 1 2 0 2147483648 ECU_ADDRESS 0x60014A34 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au32SftyCurSafeSts[3] "SWTST_au32SftyCurSafeSts[3]" ULONG Id_0x00 1 2 0 2147483648 ECU_ADDRESS 0x60014A38 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au32SftyCurSafeSts[4] "SWTST_au32SftyCurSafeSts[4]" ULONG Id_0x00 1 2 0 2147483648 ECU_ADDRESS 0x60014A3C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au32SftyCurSafeSts[5] "SWTST_au32SftyCurSafeSts[5]" ULONG Id_0x00 1 2 0 2147483648 ECU_ADDRESS 0x60014A40 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au32SftyCurSafeSts[6] "SWTST_au32SftyCurSafeSts[6]" ULONG Id_0x00 1 2 0 2147483648 ECU_ADDRESS 0x60014A44 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au32SftyCurSafeSts[7] "SWTST_au32SftyCurSafeSts[7]" ULONG Id_0x00 1 2 0 2147483648 ECU_ADDRESS 0x60014A48 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au32SftyPreSafeSts "SWTST_au32SftyPreSafeSts" ULONG Id_0x00 1 2 0 2147483648 MATRIX_DIM 8 1 1 ECU_ADDRESS 0x60014A0C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au32SftyPreSafeSts[0] "SWTST_au32SftyPreSafeSts[0]" ULONG Id_0x00 1 2 0 2147483648 ECU_ADDRESS 0x60014A0C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au32SftyPreSafeSts[1] "SWTST_au32SftyPreSafeSts[1]" ULONG Id_0x00 1 2 0 2147483648 ECU_ADDRESS 0x60014A10 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au32SftyPreSafeSts[2] "SWTST_au32SftyPreSafeSts[2]" ULONG Id_0x00 1 2 0 2147483648 ECU_ADDRESS 0x60014A14 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au32SftyPreSafeSts[3] "SWTST_au32SftyPreSafeSts[3]" ULONG Id_0x00 1 2 0 2147483648 ECU_ADDRESS 0x60014A18 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au32SftyPreSafeSts[4] "SWTST_au32SftyPreSafeSts[4]" ULONG Id_0x00 1 2 0 2147483648 ECU_ADDRESS 0x60014A1C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au32SftyPreSafeSts[5] "SWTST_au32SftyPreSafeSts[5]" ULONG Id_0x00 1 2 0 2147483648 ECU_ADDRESS 0x60014A20 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au32SftyPreSafeSts[6] "SWTST_au32SftyPreSafeSts[6]" ULONG Id_0x00 1 2 0 2147483648 ECU_ADDRESS 0x60014A24 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au32SftyPreSafeSts[7] "SWTST_au32SftyPreSafeSts[7]" ULONG Id_0x00 1 2 0 2147483648 ECU_ADDRESS 0x60014A28 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg10Can1 "SWTST_au8ComRxMsg10Can1" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x60014A04 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg10Can1[0] "SWTST_au8ComRxMsg10Can1[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014A04 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg10Can1[1] "SWTST_au8ComRxMsg10Can1[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014A08 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg10Can2 "SWTST_au8ComRxMsg10Can2" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x600149FC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg10Can2[0] "SWTST_au8ComRxMsg10Can2[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600149FC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg10Can2[1] "SWTST_au8ComRxMsg10Can2[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014A00 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg11Can1 "SWTST_au8ComRxMsg11Can1" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x600149F4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg11Can1[0] "SWTST_au8ComRxMsg11Can1[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600149F4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg11Can1[1] "SWTST_au8ComRxMsg11Can1[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600149F8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg11Can2 "SWTST_au8ComRxMsg11Can2" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x600149EC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg11Can2[0] "SWTST_au8ComRxMsg11Can2[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600149EC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg11Can2[1] "SWTST_au8ComRxMsg11Can2[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600149F0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg12Can1 "SWTST_au8ComRxMsg12Can1" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x600149E4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg12Can1[0] "SWTST_au8ComRxMsg12Can1[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600149E4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg12Can1[1] "SWTST_au8ComRxMsg12Can1[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600149E8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg12Can2 "SWTST_au8ComRxMsg12Can2" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x600149DC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg12Can2[0] "SWTST_au8ComRxMsg12Can2[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600149DC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg12Can2[1] "SWTST_au8ComRxMsg12Can2[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600149E0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg13Can1 "SWTST_au8ComRxMsg13Can1" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x600149D4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg13Can1[0] "SWTST_au8ComRxMsg13Can1[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600149D4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg13Can1[1] "SWTST_au8ComRxMsg13Can1[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600149D8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg13Can2 "SWTST_au8ComRxMsg13Can2" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x600149CC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg13Can2[0] "SWTST_au8ComRxMsg13Can2[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600149CC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg13Can2[1] "SWTST_au8ComRxMsg13Can2[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600149D0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg14Can1 "SWTST_au8ComRxMsg14Can1" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x600149C4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg14Can1[0] "SWTST_au8ComRxMsg14Can1[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600149C4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg14Can1[1] "SWTST_au8ComRxMsg14Can1[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600149C8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg14Can2 "SWTST_au8ComRxMsg14Can2" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x600149BC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg14Can2[0] "SWTST_au8ComRxMsg14Can2[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600149BC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg14Can2[1] "SWTST_au8ComRxMsg14Can2[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600149C0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg15Can1 "SWTST_au8ComRxMsg15Can1" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x600149B4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg15Can1[0] "SWTST_au8ComRxMsg15Can1[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600149B4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg15Can1[1] "SWTST_au8ComRxMsg15Can1[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600149B8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg15Can2 "SWTST_au8ComRxMsg15Can2" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x600149AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg15Can2[0] "SWTST_au8ComRxMsg15Can2[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600149AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg15Can2[1] "SWTST_au8ComRxMsg15Can2[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600149B0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg1Can1 "SWTST_au8ComRxMsg1Can1" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x600149A4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg1Can1[0] "SWTST_au8ComRxMsg1Can1[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600149A4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg1Can1[1] "SWTST_au8ComRxMsg1Can1[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600149A8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg1Can2 "SWTST_au8ComRxMsg1Can2" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x6001499C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg1Can2[0] "SWTST_au8ComRxMsg1Can2[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001499C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg1Can2[1] "SWTST_au8ComRxMsg1Can2[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600149A0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg2Can1 "SWTST_au8ComRxMsg2Can1" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x60014994 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg2Can1[0] "SWTST_au8ComRxMsg2Can1[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014994 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg2Can1[1] "SWTST_au8ComRxMsg2Can1[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014998 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg2Can2 "SWTST_au8ComRxMsg2Can2" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x6001498C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg2Can2[0] "SWTST_au8ComRxMsg2Can2[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001498C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg2Can2[1] "SWTST_au8ComRxMsg2Can2[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014990 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg3Can1 "SWTST_au8ComRxMsg3Can1" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x60014984 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg3Can1[0] "SWTST_au8ComRxMsg3Can1[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014984 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg3Can1[1] "SWTST_au8ComRxMsg3Can1[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014988 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg3Can2 "SWTST_au8ComRxMsg3Can2" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x6001497C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg3Can2[0] "SWTST_au8ComRxMsg3Can2[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001497C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg3Can2[1] "SWTST_au8ComRxMsg3Can2[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014980 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg4Can1 "SWTST_au8ComRxMsg4Can1" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x60014974 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg4Can1[0] "SWTST_au8ComRxMsg4Can1[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014974 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg4Can1[1] "SWTST_au8ComRxMsg4Can1[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014978 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg4Can2 "SWTST_au8ComRxMsg4Can2" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x6001496C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg4Can2[0] "SWTST_au8ComRxMsg4Can2[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001496C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg4Can2[1] "SWTST_au8ComRxMsg4Can2[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014970 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg5Can1 "SWTST_au8ComRxMsg5Can1" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x60014964 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg5Can1[0] "SWTST_au8ComRxMsg5Can1[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014964 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg5Can1[1] "SWTST_au8ComRxMsg5Can1[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014968 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg5Can2 "SWTST_au8ComRxMsg5Can2" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x6001495C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg5Can2[0] "SWTST_au8ComRxMsg5Can2[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001495C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg5Can2[1] "SWTST_au8ComRxMsg5Can2[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014960 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg6Can1 "SWTST_au8ComRxMsg6Can1" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x60014954 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg6Can1[0] "SWTST_au8ComRxMsg6Can1[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014954 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg6Can1[1] "SWTST_au8ComRxMsg6Can1[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014958 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg6Can2 "SWTST_au8ComRxMsg6Can2" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x6001494C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg6Can2[0] "SWTST_au8ComRxMsg6Can2[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001494C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg6Can2[1] "SWTST_au8ComRxMsg6Can2[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014950 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg7Can1 "SWTST_au8ComRxMsg7Can1" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x60014944 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg7Can1[0] "SWTST_au8ComRxMsg7Can1[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014944 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg7Can1[1] "SWTST_au8ComRxMsg7Can1[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014948 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg7Can2 "SWTST_au8ComRxMsg7Can2" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x6001493C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg7Can2[0] "SWTST_au8ComRxMsg7Can2[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001493C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg7Can2[1] "SWTST_au8ComRxMsg7Can2[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014940 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg8Can1 "SWTST_au8ComRxMsg8Can1" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x60014934 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg8Can1[0] "SWTST_au8ComRxMsg8Can1[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014934 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg8Can1[1] "SWTST_au8ComRxMsg8Can1[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014938 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg8Can2 "SWTST_au8ComRxMsg8Can2" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x6001492C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg8Can2[0] "SWTST_au8ComRxMsg8Can2[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001492C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg8Can2[1] "SWTST_au8ComRxMsg8Can2[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014930 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg9Can1 "SWTST_au8ComRxMsg9Can1" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x60014924 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg9Can1[0] "SWTST_au8ComRxMsg9Can1[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014924 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg9Can1[1] "SWTST_au8ComRxMsg9Can1[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014928 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg9Can2 "SWTST_au8ComRxMsg9Can2" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x6001491C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg9Can2[0] "SWTST_au8ComRxMsg9Can2[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001491C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComRxMsg9Can2[1] "SWTST_au8ComRxMsg9Can2[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014920 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg10Can1 "SWTST_au8ComTxMsg10Can1" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x60014914 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg10Can1[0] "SWTST_au8ComTxMsg10Can1[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014914 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg10Can1[1] "SWTST_au8ComTxMsg10Can1[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014918 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg10Can2 "SWTST_au8ComTxMsg10Can2" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x6001490C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg10Can2[0] "SWTST_au8ComTxMsg10Can2[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001490C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg10Can2[1] "SWTST_au8ComTxMsg10Can2[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014910 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg11Can1 "SWTST_au8ComTxMsg11Can1" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x60014904 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg11Can1[0] "SWTST_au8ComTxMsg11Can1[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014904 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg11Can1[1] "SWTST_au8ComTxMsg11Can1[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014908 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg11Can2 "SWTST_au8ComTxMsg11Can2" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x600148FC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg11Can2[0] "SWTST_au8ComTxMsg11Can2[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600148FC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg11Can2[1] "SWTST_au8ComTxMsg11Can2[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014900 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg12Can1 "SWTST_au8ComTxMsg12Can1" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x600148F4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg12Can1[0] "SWTST_au8ComTxMsg12Can1[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600148F4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg12Can1[1] "SWTST_au8ComTxMsg12Can1[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600148F8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg12Can2 "SWTST_au8ComTxMsg12Can2" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x600148EC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg12Can2[0] "SWTST_au8ComTxMsg12Can2[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600148EC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg12Can2[1] "SWTST_au8ComTxMsg12Can2[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600148F0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg13Can1 "SWTST_au8ComTxMsg13Can1" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x600148E4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg13Can1[0] "SWTST_au8ComTxMsg13Can1[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600148E4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg13Can1[1] "SWTST_au8ComTxMsg13Can1[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600148E8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg13Can2 "SWTST_au8ComTxMsg13Can2" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x600148DC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg13Can2[0] "SWTST_au8ComTxMsg13Can2[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600148DC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg13Can2[1] "SWTST_au8ComTxMsg13Can2[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600148E0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg14Can1 "SWTST_au8ComTxMsg14Can1" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x600148D4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg14Can1[0] "SWTST_au8ComTxMsg14Can1[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600148D4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg14Can1[1] "SWTST_au8ComTxMsg14Can1[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600148D8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg14Can2 "SWTST_au8ComTxMsg14Can2" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x600148CC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg14Can2[0] "SWTST_au8ComTxMsg14Can2[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600148CC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg14Can2[1] "SWTST_au8ComTxMsg14Can2[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600148D0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg15Can1 "SWTST_au8ComTxMsg15Can1" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x600148C4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg15Can1[0] "SWTST_au8ComTxMsg15Can1[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600148C4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg15Can1[1] "SWTST_au8ComTxMsg15Can1[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600148C8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg15Can2 "SWTST_au8ComTxMsg15Can2" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x600148BC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg15Can2[0] "SWTST_au8ComTxMsg15Can2[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600148BC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg15Can2[1] "SWTST_au8ComTxMsg15Can2[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600148C0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg1Can1 "SWTST_au8ComTxMsg1Can1" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x600148B4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg1Can1[0] "SWTST_au8ComTxMsg1Can1[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600148B4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg1Can1[1] "SWTST_au8ComTxMsg1Can1[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600148B8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg1Can2 "SWTST_au8ComTxMsg1Can2" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x600148AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg1Can2[0] "SWTST_au8ComTxMsg1Can2[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600148AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg1Can2[1] "SWTST_au8ComTxMsg1Can2[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600148B0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg2Can1 "SWTST_au8ComTxMsg2Can1" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x600148A4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg2Can1[0] "SWTST_au8ComTxMsg2Can1[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600148A4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg2Can1[1] "SWTST_au8ComTxMsg2Can1[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600148A8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg2Can2 "SWTST_au8ComTxMsg2Can2" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x6001489C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg2Can2[0] "SWTST_au8ComTxMsg2Can2[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001489C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg2Can2[1] "SWTST_au8ComTxMsg2Can2[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600148A0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg3Can1 "SWTST_au8ComTxMsg3Can1" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x60014894 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg3Can1[0] "SWTST_au8ComTxMsg3Can1[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014894 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg3Can1[1] "SWTST_au8ComTxMsg3Can1[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014898 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg3Can2 "SWTST_au8ComTxMsg3Can2" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x6001488C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg3Can2[0] "SWTST_au8ComTxMsg3Can2[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001488C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg3Can2[1] "SWTST_au8ComTxMsg3Can2[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014890 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg4Can1 "SWTST_au8ComTxMsg4Can1" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x60014884 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg4Can1[0] "SWTST_au8ComTxMsg4Can1[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014884 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg4Can1[1] "SWTST_au8ComTxMsg4Can1[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014888 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg4Can2 "SWTST_au8ComTxMsg4Can2" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x6001487C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg4Can2[0] "SWTST_au8ComTxMsg4Can2[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001487C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg4Can2[1] "SWTST_au8ComTxMsg4Can2[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014880 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg5Can1 "SWTST_au8ComTxMsg5Can1" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x60014874 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg5Can1[0] "SWTST_au8ComTxMsg5Can1[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014874 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg5Can1[1] "SWTST_au8ComTxMsg5Can1[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014878 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg5Can2 "SWTST_au8ComTxMsg5Can2" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x6001486C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg5Can2[0] "SWTST_au8ComTxMsg5Can2[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001486C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg5Can2[1] "SWTST_au8ComTxMsg5Can2[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014870 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg6Can1 "SWTST_au8ComTxMsg6Can1" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x60014864 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg6Can1[0] "SWTST_au8ComTxMsg6Can1[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014864 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg6Can1[1] "SWTST_au8ComTxMsg6Can1[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014868 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg6Can2 "SWTST_au8ComTxMsg6Can2" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x6001485C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg6Can2[0] "SWTST_au8ComTxMsg6Can2[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001485C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg6Can2[1] "SWTST_au8ComTxMsg6Can2[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014860 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg7Can1 "SWTST_au8ComTxMsg7Can1" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x60014854 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg7Can1[0] "SWTST_au8ComTxMsg7Can1[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014854 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg7Can1[1] "SWTST_au8ComTxMsg7Can1[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014858 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg7Can2 "SWTST_au8ComTxMsg7Can2" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x6001484C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg7Can2[0] "SWTST_au8ComTxMsg7Can2[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001484C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg7Can2[1] "SWTST_au8ComTxMsg7Can2[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014850 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg8Can1 "SWTST_au8ComTxMsg8Can1" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x60014844 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg8Can1[0] "SWTST_au8ComTxMsg8Can1[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014844 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg8Can1[1] "SWTST_au8ComTxMsg8Can1[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014848 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg8Can2 "SWTST_au8ComTxMsg8Can2" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x6001483C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg8Can2[0] "SWTST_au8ComTxMsg8Can2[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001483C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg8Can2[1] "SWTST_au8ComTxMsg8Can2[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014840 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg9Can1 "SWTST_au8ComTxMsg9Can1" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x60014834 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg9Can1[0] "SWTST_au8ComTxMsg9Can1[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014834 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg9Can1[1] "SWTST_au8ComTxMsg9Can1[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014838 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg9Can2 "SWTST_au8ComTxMsg9Can2" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 2 1 1 ECU_ADDRESS 0x6001482C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg9Can2[0] "SWTST_au8ComTxMsg9Can2[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001482C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8ComTxMsg9Can2[1] "SWTST_au8ComTxMsg9Can2[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014830 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist "Last test done" UBYTE I_5 1 2 0 255 MATRIX_DIM 355 1 1 ECU_ADDRESS 0x600126E9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[0] "SWTST_au8FimDemEveStsHist[0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126E9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[100] "SWTST_au8FimDemEveStsHist[100]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001274D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[101] "SWTST_au8FimDemEveStsHist[101]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001274E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[102] "SWTST_au8FimDemEveStsHist[102]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001274F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[103] "SWTST_au8FimDemEveStsHist[103]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012750 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[104] "SWTST_au8FimDemEveStsHist[104]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012751 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[105] "SWTST_au8FimDemEveStsHist[105]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012752 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[106] "SWTST_au8FimDemEveStsHist[106]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012753 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[107] "SWTST_au8FimDemEveStsHist[107]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012754 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[108] "SWTST_au8FimDemEveStsHist[108]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012755 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[109] "SWTST_au8FimDemEveStsHist[109]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012756 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[10] "SWTST_au8FimDemEveStsHist[10]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126F3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[110] "SWTST_au8FimDemEveStsHist[110]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012757 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[111] "SWTST_au8FimDemEveStsHist[111]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012758 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[112] "SWTST_au8FimDemEveStsHist[112]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012759 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[113] "SWTST_au8FimDemEveStsHist[113]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001275A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[114] "SWTST_au8FimDemEveStsHist[114]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001275B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[115] "SWTST_au8FimDemEveStsHist[115]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001275C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[116] "SWTST_au8FimDemEveStsHist[116]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001275D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[117] "SWTST_au8FimDemEveStsHist[117]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001275E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[118] "SWTST_au8FimDemEveStsHist[118]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001275F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[119] "SWTST_au8FimDemEveStsHist[119]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012760 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[11] "SWTST_au8FimDemEveStsHist[11]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126F4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[120] "SWTST_au8FimDemEveStsHist[120]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012761 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[121] "SWTST_au8FimDemEveStsHist[121]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012762 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[122] "SWTST_au8FimDemEveStsHist[122]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012763 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[123] "SWTST_au8FimDemEveStsHist[123]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012764 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[124] "SWTST_au8FimDemEveStsHist[124]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012765 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[125] "SWTST_au8FimDemEveStsHist[125]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012766 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[126] "SWTST_au8FimDemEveStsHist[126]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012767 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[127] "SWTST_au8FimDemEveStsHist[127]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012768 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[128] "SWTST_au8FimDemEveStsHist[128]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012769 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[129] "SWTST_au8FimDemEveStsHist[129]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001276A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[12] "SWTST_au8FimDemEveStsHist[12]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126F5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[130] "SWTST_au8FimDemEveStsHist[130]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001276B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[131] "SWTST_au8FimDemEveStsHist[131]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001276C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[132] "SWTST_au8FimDemEveStsHist[132]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001276D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[133] "SWTST_au8FimDemEveStsHist[133]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001276E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[134] "SWTST_au8FimDemEveStsHist[134]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001276F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[135] "SWTST_au8FimDemEveStsHist[135]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012770 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[136] "SWTST_au8FimDemEveStsHist[136]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012771 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[137] "SWTST_au8FimDemEveStsHist[137]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012772 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[138] "SWTST_au8FimDemEveStsHist[138]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012773 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[139] "SWTST_au8FimDemEveStsHist[139]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012774 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[13] "SWTST_au8FimDemEveStsHist[13]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126F6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[140] "SWTST_au8FimDemEveStsHist[140]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012775 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[141] "SWTST_au8FimDemEveStsHist[141]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012776 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[142] "SWTST_au8FimDemEveStsHist[142]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012777 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[143] "SWTST_au8FimDemEveStsHist[143]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012778 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[144] "SWTST_au8FimDemEveStsHist[144]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012779 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[145] "SWTST_au8FimDemEveStsHist[145]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001277A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[146] "SWTST_au8FimDemEveStsHist[146]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001277B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[147] "SWTST_au8FimDemEveStsHist[147]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001277C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[148] "SWTST_au8FimDemEveStsHist[148]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001277D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[149] "SWTST_au8FimDemEveStsHist[149]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001277E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[14] "SWTST_au8FimDemEveStsHist[14]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126F7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[150] "SWTST_au8FimDemEveStsHist[150]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001277F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[151] "SWTST_au8FimDemEveStsHist[151]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012780 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[152] "SWTST_au8FimDemEveStsHist[152]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012781 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[153] "SWTST_au8FimDemEveStsHist[153]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012782 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[154] "SWTST_au8FimDemEveStsHist[154]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012783 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[155] "SWTST_au8FimDemEveStsHist[155]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012784 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[156] "SWTST_au8FimDemEveStsHist[156]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012785 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[157] "SWTST_au8FimDemEveStsHist[157]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012786 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[158] "SWTST_au8FimDemEveStsHist[158]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012787 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[159] "SWTST_au8FimDemEveStsHist[159]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012788 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[15] "SWTST_au8FimDemEveStsHist[15]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126F8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[160] "SWTST_au8FimDemEveStsHist[160]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012789 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[161] "SWTST_au8FimDemEveStsHist[161]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001278A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[162] "SWTST_au8FimDemEveStsHist[162]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001278B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[163] "SWTST_au8FimDemEveStsHist[163]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001278C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[164] "SWTST_au8FimDemEveStsHist[164]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001278D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[165] "SWTST_au8FimDemEveStsHist[165]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001278E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[166] "SWTST_au8FimDemEveStsHist[166]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001278F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[167] "SWTST_au8FimDemEveStsHist[167]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012790 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[168] "SWTST_au8FimDemEveStsHist[168]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012791 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[169] "SWTST_au8FimDemEveStsHist[169]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012792 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[16] "SWTST_au8FimDemEveStsHist[16]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126F9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[170] "SWTST_au8FimDemEveStsHist[170]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012793 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[171] "SWTST_au8FimDemEveStsHist[171]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012794 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[172] "SWTST_au8FimDemEveStsHist[172]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012795 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[173] "SWTST_au8FimDemEveStsHist[173]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012796 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[174] "SWTST_au8FimDemEveStsHist[174]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012797 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[175] "SWTST_au8FimDemEveStsHist[175]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012798 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[176] "SWTST_au8FimDemEveStsHist[176]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012799 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[177] "SWTST_au8FimDemEveStsHist[177]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001279A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[178] "SWTST_au8FimDemEveStsHist[178]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001279B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[179] "SWTST_au8FimDemEveStsHist[179]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001279C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[17] "SWTST_au8FimDemEveStsHist[17]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126FA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[180] "SWTST_au8FimDemEveStsHist[180]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001279D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[181] "SWTST_au8FimDemEveStsHist[181]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001279E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[182] "SWTST_au8FimDemEveStsHist[182]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001279F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[183] "SWTST_au8FimDemEveStsHist[183]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127A0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[184] "SWTST_au8FimDemEveStsHist[184]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127A1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[185] "SWTST_au8FimDemEveStsHist[185]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127A2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[186] "SWTST_au8FimDemEveStsHist[186]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127A3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[187] "SWTST_au8FimDemEveStsHist[187]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127A4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[188] "SWTST_au8FimDemEveStsHist[188]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127A5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[189] "SWTST_au8FimDemEveStsHist[189]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127A6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[18] "SWTST_au8FimDemEveStsHist[18]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126FB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[190] "SWTST_au8FimDemEveStsHist[190]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127A7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[191] "SWTST_au8FimDemEveStsHist[191]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127A8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[192] "SWTST_au8FimDemEveStsHist[192]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127A9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[193] "SWTST_au8FimDemEveStsHist[193]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127AA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[194] "SWTST_au8FimDemEveStsHist[194]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127AB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[195] "SWTST_au8FimDemEveStsHist[195]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[196] "SWTST_au8FimDemEveStsHist[196]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127AD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[197] "SWTST_au8FimDemEveStsHist[197]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127AE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[198] "SWTST_au8FimDemEveStsHist[198]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127AF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[199] "SWTST_au8FimDemEveStsHist[199]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127B0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[19] "SWTST_au8FimDemEveStsHist[19]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126FC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[1] "SWTST_au8FimDemEveStsHist[1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126EA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[200] "SWTST_au8FimDemEveStsHist[200]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127B1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[201] "SWTST_au8FimDemEveStsHist[201]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127B2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[202] "SWTST_au8FimDemEveStsHist[202]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127B3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[203] "SWTST_au8FimDemEveStsHist[203]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127B4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[204] "SWTST_au8FimDemEveStsHist[204]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127B5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[205] "SWTST_au8FimDemEveStsHist[205]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127B6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[206] "SWTST_au8FimDemEveStsHist[206]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127B7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[207] "SWTST_au8FimDemEveStsHist[207]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127B8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[208] "SWTST_au8FimDemEveStsHist[208]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127B9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[209] "SWTST_au8FimDemEveStsHist[209]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127BA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[20] "SWTST_au8FimDemEveStsHist[20]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126FD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[210] "SWTST_au8FimDemEveStsHist[210]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127BB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[211] "SWTST_au8FimDemEveStsHist[211]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127BC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[212] "SWTST_au8FimDemEveStsHist[212]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127BD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[213] "SWTST_au8FimDemEveStsHist[213]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127BE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[214] "SWTST_au8FimDemEveStsHist[214]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127BF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[215] "SWTST_au8FimDemEveStsHist[215]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127C0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[216] "SWTST_au8FimDemEveStsHist[216]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127C1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[217] "SWTST_au8FimDemEveStsHist[217]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127C2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[218] "SWTST_au8FimDemEveStsHist[218]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127C3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[219] "SWTST_au8FimDemEveStsHist[219]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127C4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[21] "SWTST_au8FimDemEveStsHist[21]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126FE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[220] "SWTST_au8FimDemEveStsHist[220]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127C5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[221] "SWTST_au8FimDemEveStsHist[221]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127C6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[222] "SWTST_au8FimDemEveStsHist[222]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127C7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[223] "SWTST_au8FimDemEveStsHist[223]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127C8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[224] "SWTST_au8FimDemEveStsHist[224]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127C9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[225] "SWTST_au8FimDemEveStsHist[225]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127CA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[226] "SWTST_au8FimDemEveStsHist[226]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127CB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[227] "SWTST_au8FimDemEveStsHist[227]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127CC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[228] "SWTST_au8FimDemEveStsHist[228]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127CD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[229] "SWTST_au8FimDemEveStsHist[229]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127CE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[22] "SWTST_au8FimDemEveStsHist[22]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126FF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[230] "SWTST_au8FimDemEveStsHist[230]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127CF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[231] "SWTST_au8FimDemEveStsHist[231]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127D0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[232] "SWTST_au8FimDemEveStsHist[232]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127D1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[233] "SWTST_au8FimDemEveStsHist[233]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127D2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[234] "SWTST_au8FimDemEveStsHist[234]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127D3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[235] "SWTST_au8FimDemEveStsHist[235]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127D4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[236] "SWTST_au8FimDemEveStsHist[236]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127D5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[237] "SWTST_au8FimDemEveStsHist[237]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127D6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[238] "SWTST_au8FimDemEveStsHist[238]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127D7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[239] "SWTST_au8FimDemEveStsHist[239]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127D8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[23] "SWTST_au8FimDemEveStsHist[23]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012700 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[240] "SWTST_au8FimDemEveStsHist[240]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127D9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[241] "SWTST_au8FimDemEveStsHist[241]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127DA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[242] "SWTST_au8FimDemEveStsHist[242]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127DB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[243] "SWTST_au8FimDemEveStsHist[243]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127DC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[244] "SWTST_au8FimDemEveStsHist[244]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127DD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[245] "SWTST_au8FimDemEveStsHist[245]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127DE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[246] "SWTST_au8FimDemEveStsHist[246]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127DF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[247] "SWTST_au8FimDemEveStsHist[247]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127E0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[248] "SWTST_au8FimDemEveStsHist[248]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127E1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[249] "SWTST_au8FimDemEveStsHist[249]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127E2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[24] "SWTST_au8FimDemEveStsHist[24]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012701 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[250] "SWTST_au8FimDemEveStsHist[250]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127E3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[251] "SWTST_au8FimDemEveStsHist[251]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127E4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[252] "SWTST_au8FimDemEveStsHist[252]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127E5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[253] "SWTST_au8FimDemEveStsHist[253]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127E6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[254] "SWTST_au8FimDemEveStsHist[254]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127E7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[255] "SWTST_au8FimDemEveStsHist[255]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127E8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[256] "SWTST_au8FimDemEveStsHist[256]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127E9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[257] "SWTST_au8FimDemEveStsHist[257]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127EA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[258] "SWTST_au8FimDemEveStsHist[258]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127EB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[259] "SWTST_au8FimDemEveStsHist[259]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127EC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[25] "SWTST_au8FimDemEveStsHist[25]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012702 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[260] "SWTST_au8FimDemEveStsHist[260]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127ED READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[261] "SWTST_au8FimDemEveStsHist[261]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127EE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[262] "SWTST_au8FimDemEveStsHist[262]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127EF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[263] "SWTST_au8FimDemEveStsHist[263]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127F0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[264] "SWTST_au8FimDemEveStsHist[264]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127F1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[265] "SWTST_au8FimDemEveStsHist[265]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127F2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[266] "SWTST_au8FimDemEveStsHist[266]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127F3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[267] "SWTST_au8FimDemEveStsHist[267]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127F4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[268] "SWTST_au8FimDemEveStsHist[268]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127F5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[269] "SWTST_au8FimDemEveStsHist[269]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127F6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[26] "SWTST_au8FimDemEveStsHist[26]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012703 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[270] "SWTST_au8FimDemEveStsHist[270]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127F7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[271] "SWTST_au8FimDemEveStsHist[271]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127F8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[272] "SWTST_au8FimDemEveStsHist[272]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127F9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[273] "SWTST_au8FimDemEveStsHist[273]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127FA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[274] "SWTST_au8FimDemEveStsHist[274]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127FB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[275] "SWTST_au8FimDemEveStsHist[275]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127FC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[276] "SWTST_au8FimDemEveStsHist[276]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127FD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[277] "SWTST_au8FimDemEveStsHist[277]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127FE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[278] "SWTST_au8FimDemEveStsHist[278]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600127FF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[279] "SWTST_au8FimDemEveStsHist[279]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012800 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[27] "SWTST_au8FimDemEveStsHist[27]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012704 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[280] "SWTST_au8FimDemEveStsHist[280]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012801 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[281] "SWTST_au8FimDemEveStsHist[281]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012802 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[282] "SWTST_au8FimDemEveStsHist[282]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012803 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[283] "SWTST_au8FimDemEveStsHist[283]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012804 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[284] "SWTST_au8FimDemEveStsHist[284]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012805 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[285] "SWTST_au8FimDemEveStsHist[285]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012806 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[286] "SWTST_au8FimDemEveStsHist[286]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012807 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[287] "SWTST_au8FimDemEveStsHist[287]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012808 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[288] "SWTST_au8FimDemEveStsHist[288]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012809 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[289] "SWTST_au8FimDemEveStsHist[289]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001280A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[28] "SWTST_au8FimDemEveStsHist[28]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012705 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[290] "SWTST_au8FimDemEveStsHist[290]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001280B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[291] "SWTST_au8FimDemEveStsHist[291]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001280C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[292] "SWTST_au8FimDemEveStsHist[292]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001280D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[293] "SWTST_au8FimDemEveStsHist[293]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001280E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[294] "SWTST_au8FimDemEveStsHist[294]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001280F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[295] "SWTST_au8FimDemEveStsHist[295]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012810 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[296] "SWTST_au8FimDemEveStsHist[296]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012811 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[297] "SWTST_au8FimDemEveStsHist[297]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012812 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[298] "SWTST_au8FimDemEveStsHist[298]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012813 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[299] "SWTST_au8FimDemEveStsHist[299]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012814 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[29] "SWTST_au8FimDemEveStsHist[29]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012706 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[2] "SWTST_au8FimDemEveStsHist[2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126EB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[300] "SWTST_au8FimDemEveStsHist[300]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012815 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[301] "SWTST_au8FimDemEveStsHist[301]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012816 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[302] "SWTST_au8FimDemEveStsHist[302]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012817 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[303] "SWTST_au8FimDemEveStsHist[303]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012818 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[304] "SWTST_au8FimDemEveStsHist[304]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012819 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[305] "SWTST_au8FimDemEveStsHist[305]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001281A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[306] "SWTST_au8FimDemEveStsHist[306]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001281B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[307] "SWTST_au8FimDemEveStsHist[307]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001281C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[308] "SWTST_au8FimDemEveStsHist[308]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001281D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[309] "SWTST_au8FimDemEveStsHist[309]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001281E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[30] "SWTST_au8FimDemEveStsHist[30]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012707 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[310] "SWTST_au8FimDemEveStsHist[310]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001281F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[311] "SWTST_au8FimDemEveStsHist[311]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012820 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[312] "SWTST_au8FimDemEveStsHist[312]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012821 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[313] "SWTST_au8FimDemEveStsHist[313]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012822 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[314] "SWTST_au8FimDemEveStsHist[314]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012823 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[315] "SWTST_au8FimDemEveStsHist[315]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012824 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[316] "SWTST_au8FimDemEveStsHist[316]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012825 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[317] "SWTST_au8FimDemEveStsHist[317]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012826 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[318] "SWTST_au8FimDemEveStsHist[318]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012827 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[319] "SWTST_au8FimDemEveStsHist[319]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012828 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[31] "SWTST_au8FimDemEveStsHist[31]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012708 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[320] "SWTST_au8FimDemEveStsHist[320]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012829 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[321] "SWTST_au8FimDemEveStsHist[321]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001282A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[322] "SWTST_au8FimDemEveStsHist[322]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001282B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[323] "SWTST_au8FimDemEveStsHist[323]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001282C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[324] "SWTST_au8FimDemEveStsHist[324]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001282D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[325] "SWTST_au8FimDemEveStsHist[325]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001282E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[326] "SWTST_au8FimDemEveStsHist[326]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001282F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[327] "SWTST_au8FimDemEveStsHist[327]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012830 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[328] "SWTST_au8FimDemEveStsHist[328]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012831 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[329] "SWTST_au8FimDemEveStsHist[329]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012832 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[32] "SWTST_au8FimDemEveStsHist[32]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012709 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[330] "SWTST_au8FimDemEveStsHist[330]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012833 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[331] "SWTST_au8FimDemEveStsHist[331]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012834 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[332] "SWTST_au8FimDemEveStsHist[332]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012835 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[333] "SWTST_au8FimDemEveStsHist[333]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012836 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[334] "SWTST_au8FimDemEveStsHist[334]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012837 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[335] "SWTST_au8FimDemEveStsHist[335]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012838 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[336] "SWTST_au8FimDemEveStsHist[336]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012839 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[337] "SWTST_au8FimDemEveStsHist[337]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001283A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[338] "SWTST_au8FimDemEveStsHist[338]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001283B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[339] "SWTST_au8FimDemEveStsHist[339]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001283C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[33] "SWTST_au8FimDemEveStsHist[33]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001270A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[340] "SWTST_au8FimDemEveStsHist[340]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001283D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[341] "SWTST_au8FimDemEveStsHist[341]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001283E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[342] "SWTST_au8FimDemEveStsHist[342]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001283F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[343] "SWTST_au8FimDemEveStsHist[343]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012840 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[344] "SWTST_au8FimDemEveStsHist[344]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012841 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[345] "SWTST_au8FimDemEveStsHist[345]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012842 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[346] "SWTST_au8FimDemEveStsHist[346]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012843 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[347] "SWTST_au8FimDemEveStsHist[347]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012844 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[348] "SWTST_au8FimDemEveStsHist[348]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012845 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[349] "SWTST_au8FimDemEveStsHist[349]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012846 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[34] "SWTST_au8FimDemEveStsHist[34]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001270B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[350] "SWTST_au8FimDemEveStsHist[350]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012847 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[351] "SWTST_au8FimDemEveStsHist[351]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012848 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[352] "SWTST_au8FimDemEveStsHist[352]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012849 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[353] "SWTST_au8FimDemEveStsHist[353]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001284A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[354] "SWTST_au8FimDemEveStsHist[354]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001284B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[35] "SWTST_au8FimDemEveStsHist[35]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001270C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[36] "SWTST_au8FimDemEveStsHist[36]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001270D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[37] "SWTST_au8FimDemEveStsHist[37]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001270E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[38] "SWTST_au8FimDemEveStsHist[38]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001270F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[39] "SWTST_au8FimDemEveStsHist[39]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012710 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[3] "SWTST_au8FimDemEveStsHist[3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126EC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[40] "SWTST_au8FimDemEveStsHist[40]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012711 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[41] "SWTST_au8FimDemEveStsHist[41]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012712 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[42] "SWTST_au8FimDemEveStsHist[42]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012713 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[43] "SWTST_au8FimDemEveStsHist[43]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012714 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[44] "SWTST_au8FimDemEveStsHist[44]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012715 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[45] "SWTST_au8FimDemEveStsHist[45]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012716 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[46] "SWTST_au8FimDemEveStsHist[46]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012717 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[47] "SWTST_au8FimDemEveStsHist[47]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012718 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[48] "SWTST_au8FimDemEveStsHist[48]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012719 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[49] "SWTST_au8FimDemEveStsHist[49]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001271A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[4] "SWTST_au8FimDemEveStsHist[4]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126ED READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[50] "SWTST_au8FimDemEveStsHist[50]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001271B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[51] "SWTST_au8FimDemEveStsHist[51]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001271C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[52] "SWTST_au8FimDemEveStsHist[52]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001271D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[53] "SWTST_au8FimDemEveStsHist[53]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001271E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[54] "SWTST_au8FimDemEveStsHist[54]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001271F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[55] "SWTST_au8FimDemEveStsHist[55]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012720 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[56] "SWTST_au8FimDemEveStsHist[56]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012721 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[57] "SWTST_au8FimDemEveStsHist[57]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012722 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[58] "SWTST_au8FimDemEveStsHist[58]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012723 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[59] "SWTST_au8FimDemEveStsHist[59]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012724 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[5] "SWTST_au8FimDemEveStsHist[5]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126EE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[60] "SWTST_au8FimDemEveStsHist[60]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012725 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[61] "SWTST_au8FimDemEveStsHist[61]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012726 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[62] "SWTST_au8FimDemEveStsHist[62]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012727 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[63] "SWTST_au8FimDemEveStsHist[63]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012728 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[64] "SWTST_au8FimDemEveStsHist[64]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012729 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[65] "SWTST_au8FimDemEveStsHist[65]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001272A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[66] "SWTST_au8FimDemEveStsHist[66]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001272B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[67] "SWTST_au8FimDemEveStsHist[67]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001272C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[68] "SWTST_au8FimDemEveStsHist[68]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001272D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[69] "SWTST_au8FimDemEveStsHist[69]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001272E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[6] "SWTST_au8FimDemEveStsHist[6]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126EF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[70] "SWTST_au8FimDemEveStsHist[70]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001272F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[71] "SWTST_au8FimDemEveStsHist[71]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012730 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[72] "SWTST_au8FimDemEveStsHist[72]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012731 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[73] "SWTST_au8FimDemEveStsHist[73]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012732 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[74] "SWTST_au8FimDemEveStsHist[74]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012733 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[75] "SWTST_au8FimDemEveStsHist[75]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012734 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[76] "SWTST_au8FimDemEveStsHist[76]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012735 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[77] "SWTST_au8FimDemEveStsHist[77]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012736 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[78] "SWTST_au8FimDemEveStsHist[78]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012737 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[79] "SWTST_au8FimDemEveStsHist[79]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012738 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[7] "SWTST_au8FimDemEveStsHist[7]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126F0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[80] "SWTST_au8FimDemEveStsHist[80]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012739 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[81] "SWTST_au8FimDemEveStsHist[81]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001273A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[82] "SWTST_au8FimDemEveStsHist[82]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001273B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[83] "SWTST_au8FimDemEveStsHist[83]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001273C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[84] "SWTST_au8FimDemEveStsHist[84]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001273D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[85] "SWTST_au8FimDemEveStsHist[85]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001273E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[86] "SWTST_au8FimDemEveStsHist[86]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001273F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[87] "SWTST_au8FimDemEveStsHist[87]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012740 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[88] "SWTST_au8FimDemEveStsHist[88]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012741 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[89] "SWTST_au8FimDemEveStsHist[89]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012742 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[8] "SWTST_au8FimDemEveStsHist[8]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126F1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[90] "SWTST_au8FimDemEveStsHist[90]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012743 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[91] "SWTST_au8FimDemEveStsHist[91]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012744 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[92] "SWTST_au8FimDemEveStsHist[92]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012745 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[93] "SWTST_au8FimDemEveStsHist[93]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012746 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[94] "SWTST_au8FimDemEveStsHist[94]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012747 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[95] "SWTST_au8FimDemEveStsHist[95]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012748 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[96] "SWTST_au8FimDemEveStsHist[96]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012749 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[97] "SWTST_au8FimDemEveStsHist[97]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001274A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[98] "SWTST_au8FimDemEveStsHist[98]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001274B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[99] "SWTST_au8FimDemEveStsHist[99]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001274C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsHist[9] "SWTST_au8FimDemEveStsHist[9]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126F2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal "Last test done" UBYTE I_5 1 2 0 255 MATRIX_DIM 355 1 1 ECU_ADDRESS 0x60012586 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[0] "SWTST_au8FimDemEveStsReal[0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012586 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[100] "SWTST_au8FimDemEveStsReal[100]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125EA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[101] "SWTST_au8FimDemEveStsReal[101]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125EB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[102] "SWTST_au8FimDemEveStsReal[102]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125EC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[103] "SWTST_au8FimDemEveStsReal[103]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125ED READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[104] "SWTST_au8FimDemEveStsReal[104]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125EE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[105] "SWTST_au8FimDemEveStsReal[105]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125EF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[106] "SWTST_au8FimDemEveStsReal[106]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125F0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[107] "SWTST_au8FimDemEveStsReal[107]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125F1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[108] "SWTST_au8FimDemEveStsReal[108]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125F2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[109] "SWTST_au8FimDemEveStsReal[109]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125F3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[10] "SWTST_au8FimDemEveStsReal[10]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012590 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[110] "SWTST_au8FimDemEveStsReal[110]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125F4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[111] "SWTST_au8FimDemEveStsReal[111]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125F5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[112] "SWTST_au8FimDemEveStsReal[112]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125F6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[113] "SWTST_au8FimDemEveStsReal[113]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125F7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[114] "SWTST_au8FimDemEveStsReal[114]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125F8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[115] "SWTST_au8FimDemEveStsReal[115]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125F9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[116] "SWTST_au8FimDemEveStsReal[116]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125FA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[117] "SWTST_au8FimDemEveStsReal[117]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125FB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[118] "SWTST_au8FimDemEveStsReal[118]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125FC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[119] "SWTST_au8FimDemEveStsReal[119]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125FD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[11] "SWTST_au8FimDemEveStsReal[11]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012591 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[120] "SWTST_au8FimDemEveStsReal[120]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125FE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[121] "SWTST_au8FimDemEveStsReal[121]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125FF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[122] "SWTST_au8FimDemEveStsReal[122]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012600 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[123] "SWTST_au8FimDemEveStsReal[123]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012601 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[124] "SWTST_au8FimDemEveStsReal[124]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012602 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[125] "SWTST_au8FimDemEveStsReal[125]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012603 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[126] "SWTST_au8FimDemEveStsReal[126]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012604 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[127] "SWTST_au8FimDemEveStsReal[127]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012605 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[128] "SWTST_au8FimDemEveStsReal[128]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012606 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[129] "SWTST_au8FimDemEveStsReal[129]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012607 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[12] "SWTST_au8FimDemEveStsReal[12]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012592 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[130] "SWTST_au8FimDemEveStsReal[130]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012608 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[131] "SWTST_au8FimDemEveStsReal[131]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012609 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[132] "SWTST_au8FimDemEveStsReal[132]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001260A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[133] "SWTST_au8FimDemEveStsReal[133]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001260B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[134] "SWTST_au8FimDemEveStsReal[134]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001260C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[135] "SWTST_au8FimDemEveStsReal[135]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001260D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[136] "SWTST_au8FimDemEveStsReal[136]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001260E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[137] "SWTST_au8FimDemEveStsReal[137]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001260F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[138] "SWTST_au8FimDemEveStsReal[138]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012610 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[139] "SWTST_au8FimDemEveStsReal[139]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012611 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[13] "SWTST_au8FimDemEveStsReal[13]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012593 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[140] "SWTST_au8FimDemEveStsReal[140]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012612 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[141] "SWTST_au8FimDemEveStsReal[141]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012613 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[142] "SWTST_au8FimDemEveStsReal[142]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012614 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[143] "SWTST_au8FimDemEveStsReal[143]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012615 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[144] "SWTST_au8FimDemEveStsReal[144]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012616 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[145] "SWTST_au8FimDemEveStsReal[145]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012617 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[146] "SWTST_au8FimDemEveStsReal[146]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012618 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[147] "SWTST_au8FimDemEveStsReal[147]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012619 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[148] "SWTST_au8FimDemEveStsReal[148]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001261A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[149] "SWTST_au8FimDemEveStsReal[149]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001261B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[14] "SWTST_au8FimDemEveStsReal[14]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012594 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[150] "SWTST_au8FimDemEveStsReal[150]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001261C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[151] "SWTST_au8FimDemEveStsReal[151]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001261D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[152] "SWTST_au8FimDemEveStsReal[152]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001261E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[153] "SWTST_au8FimDemEveStsReal[153]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001261F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[154] "SWTST_au8FimDemEveStsReal[154]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012620 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[155] "SWTST_au8FimDemEveStsReal[155]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012621 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[156] "SWTST_au8FimDemEveStsReal[156]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012622 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[157] "SWTST_au8FimDemEveStsReal[157]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012623 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[158] "SWTST_au8FimDemEveStsReal[158]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012624 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[159] "SWTST_au8FimDemEveStsReal[159]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012625 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[15] "SWTST_au8FimDemEveStsReal[15]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012595 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[160] "SWTST_au8FimDemEveStsReal[160]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012626 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[161] "SWTST_au8FimDemEveStsReal[161]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012627 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[162] "SWTST_au8FimDemEveStsReal[162]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012628 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[163] "SWTST_au8FimDemEveStsReal[163]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012629 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[164] "SWTST_au8FimDemEveStsReal[164]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001262A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[165] "SWTST_au8FimDemEveStsReal[165]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001262B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[166] "SWTST_au8FimDemEveStsReal[166]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001262C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[167] "SWTST_au8FimDemEveStsReal[167]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001262D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[168] "SWTST_au8FimDemEveStsReal[168]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001262E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[169] "SWTST_au8FimDemEveStsReal[169]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001262F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[16] "SWTST_au8FimDemEveStsReal[16]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012596 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[170] "SWTST_au8FimDemEveStsReal[170]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012630 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[171] "SWTST_au8FimDemEveStsReal[171]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012631 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[172] "SWTST_au8FimDemEveStsReal[172]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012632 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[173] "SWTST_au8FimDemEveStsReal[173]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012633 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[174] "SWTST_au8FimDemEveStsReal[174]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012634 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[175] "SWTST_au8FimDemEveStsReal[175]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012635 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[176] "SWTST_au8FimDemEveStsReal[176]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012636 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[177] "SWTST_au8FimDemEveStsReal[177]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012637 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[178] "SWTST_au8FimDemEveStsReal[178]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012638 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[179] "SWTST_au8FimDemEveStsReal[179]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012639 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[17] "SWTST_au8FimDemEveStsReal[17]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012597 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[180] "SWTST_au8FimDemEveStsReal[180]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001263A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[181] "SWTST_au8FimDemEveStsReal[181]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001263B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[182] "SWTST_au8FimDemEveStsReal[182]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001263C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[183] "SWTST_au8FimDemEveStsReal[183]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001263D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[184] "SWTST_au8FimDemEveStsReal[184]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001263E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[185] "SWTST_au8FimDemEveStsReal[185]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001263F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[186] "SWTST_au8FimDemEveStsReal[186]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012640 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[187] "SWTST_au8FimDemEveStsReal[187]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012641 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[188] "SWTST_au8FimDemEveStsReal[188]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012642 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[189] "SWTST_au8FimDemEveStsReal[189]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012643 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[18] "SWTST_au8FimDemEveStsReal[18]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012598 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[190] "SWTST_au8FimDemEveStsReal[190]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012644 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[191] "SWTST_au8FimDemEveStsReal[191]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012645 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[192] "SWTST_au8FimDemEveStsReal[192]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012646 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[193] "SWTST_au8FimDemEveStsReal[193]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012647 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[194] "SWTST_au8FimDemEveStsReal[194]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012648 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[195] "SWTST_au8FimDemEveStsReal[195]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012649 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[196] "SWTST_au8FimDemEveStsReal[196]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001264A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[197] "SWTST_au8FimDemEveStsReal[197]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001264B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[198] "SWTST_au8FimDemEveStsReal[198]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001264C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[199] "SWTST_au8FimDemEveStsReal[199]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001264D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[19] "SWTST_au8FimDemEveStsReal[19]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012599 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[1] "SWTST_au8FimDemEveStsReal[1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012587 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[200] "SWTST_au8FimDemEveStsReal[200]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001264E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[201] "SWTST_au8FimDemEveStsReal[201]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001264F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[202] "SWTST_au8FimDemEveStsReal[202]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012650 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[203] "SWTST_au8FimDemEveStsReal[203]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012651 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[204] "SWTST_au8FimDemEveStsReal[204]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012652 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[205] "SWTST_au8FimDemEveStsReal[205]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012653 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[206] "SWTST_au8FimDemEveStsReal[206]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012654 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[207] "SWTST_au8FimDemEveStsReal[207]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012655 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[208] "SWTST_au8FimDemEveStsReal[208]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012656 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[209] "SWTST_au8FimDemEveStsReal[209]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012657 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[20] "SWTST_au8FimDemEveStsReal[20]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001259A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[210] "SWTST_au8FimDemEveStsReal[210]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012658 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[211] "SWTST_au8FimDemEveStsReal[211]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012659 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[212] "SWTST_au8FimDemEveStsReal[212]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001265A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[213] "SWTST_au8FimDemEveStsReal[213]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001265B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[214] "SWTST_au8FimDemEveStsReal[214]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001265C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[215] "SWTST_au8FimDemEveStsReal[215]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001265D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[216] "SWTST_au8FimDemEveStsReal[216]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001265E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[217] "SWTST_au8FimDemEveStsReal[217]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001265F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[218] "SWTST_au8FimDemEveStsReal[218]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012660 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[219] "SWTST_au8FimDemEveStsReal[219]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012661 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[21] "SWTST_au8FimDemEveStsReal[21]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001259B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[220] "SWTST_au8FimDemEveStsReal[220]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012662 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[221] "SWTST_au8FimDemEveStsReal[221]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012663 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[222] "SWTST_au8FimDemEveStsReal[222]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012664 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[223] "SWTST_au8FimDemEveStsReal[223]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012665 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[224] "SWTST_au8FimDemEveStsReal[224]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012666 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[225] "SWTST_au8FimDemEveStsReal[225]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012667 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[226] "SWTST_au8FimDemEveStsReal[226]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012668 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[227] "SWTST_au8FimDemEveStsReal[227]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012669 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[228] "SWTST_au8FimDemEveStsReal[228]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001266A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[229] "SWTST_au8FimDemEveStsReal[229]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001266B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[22] "SWTST_au8FimDemEveStsReal[22]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001259C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[230] "SWTST_au8FimDemEveStsReal[230]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001266C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[231] "SWTST_au8FimDemEveStsReal[231]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001266D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[232] "SWTST_au8FimDemEveStsReal[232]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001266E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[233] "SWTST_au8FimDemEveStsReal[233]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001266F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[234] "SWTST_au8FimDemEveStsReal[234]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012670 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[235] "SWTST_au8FimDemEveStsReal[235]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012671 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[236] "SWTST_au8FimDemEveStsReal[236]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012672 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[237] "SWTST_au8FimDemEveStsReal[237]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012673 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[238] "SWTST_au8FimDemEveStsReal[238]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012674 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[239] "SWTST_au8FimDemEveStsReal[239]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012675 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[23] "SWTST_au8FimDemEveStsReal[23]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001259D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[240] "SWTST_au8FimDemEveStsReal[240]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012676 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[241] "SWTST_au8FimDemEveStsReal[241]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012677 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[242] "SWTST_au8FimDemEveStsReal[242]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012678 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[243] "SWTST_au8FimDemEveStsReal[243]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012679 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[244] "SWTST_au8FimDemEveStsReal[244]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001267A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[245] "SWTST_au8FimDemEveStsReal[245]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001267B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[246] "SWTST_au8FimDemEveStsReal[246]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001267C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[247] "SWTST_au8FimDemEveStsReal[247]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001267D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[248] "SWTST_au8FimDemEveStsReal[248]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001267E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[249] "SWTST_au8FimDemEveStsReal[249]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001267F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[24] "SWTST_au8FimDemEveStsReal[24]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001259E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[250] "SWTST_au8FimDemEveStsReal[250]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012680 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[251] "SWTST_au8FimDemEveStsReal[251]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012681 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[252] "SWTST_au8FimDemEveStsReal[252]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012682 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[253] "SWTST_au8FimDemEveStsReal[253]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012683 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[254] "SWTST_au8FimDemEveStsReal[254]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012684 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[255] "SWTST_au8FimDemEveStsReal[255]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012685 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[256] "SWTST_au8FimDemEveStsReal[256]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012686 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[257] "SWTST_au8FimDemEveStsReal[257]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012687 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[258] "SWTST_au8FimDemEveStsReal[258]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012688 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[259] "SWTST_au8FimDemEveStsReal[259]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012689 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[25] "SWTST_au8FimDemEveStsReal[25]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001259F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[260] "SWTST_au8FimDemEveStsReal[260]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001268A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[261] "SWTST_au8FimDemEveStsReal[261]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001268B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[262] "SWTST_au8FimDemEveStsReal[262]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001268C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[263] "SWTST_au8FimDemEveStsReal[263]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001268D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[264] "SWTST_au8FimDemEveStsReal[264]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001268E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[265] "SWTST_au8FimDemEveStsReal[265]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001268F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[266] "SWTST_au8FimDemEveStsReal[266]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012690 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[267] "SWTST_au8FimDemEveStsReal[267]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012691 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[268] "SWTST_au8FimDemEveStsReal[268]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012692 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState "tlf35584 diagnostic state" UBYTE I_5 1 2 0 255 MATRIX_DIM 100 1 1 ECU_ADDRESS 0x6001284C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[0] "SmTlf_enuState[0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001284C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[10] "SmTlf_enuState[10]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012856 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[11] "SmTlf_enuState[11]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012857 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[12] "SmTlf_enuState[12]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012858 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[13] "SmTlf_enuState[13]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012859 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[14] "SmTlf_enuState[14]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001285A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[15] "SmTlf_enuState[15]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001285B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[16] "SmTlf_enuState[16]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001285C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[17] "SmTlf_enuState[17]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001285D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[18] "SmTlf_enuState[18]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001285E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[19] "SmTlf_enuState[19]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001285F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[1] "SmTlf_enuState[1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001284D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[20] "SmTlf_enuState[20]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012860 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[21] "SmTlf_enuState[21]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012861 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[22] "SmTlf_enuState[22]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012862 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[23] "SmTlf_enuState[23]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012863 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[24] "SmTlf_enuState[24]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012864 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[25] "SmTlf_enuState[25]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012865 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[26] "SmTlf_enuState[26]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012866 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[27] "SmTlf_enuState[27]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012867 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[28] "SmTlf_enuState[28]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012868 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[29] "SmTlf_enuState[29]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012869 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[2] "SmTlf_enuState[2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001284E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[30] "SmTlf_enuState[30]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001286A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[31] "SmTlf_enuState[31]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001286B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[32] "SmTlf_enuState[32]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001286C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[33] "SmTlf_enuState[33]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001286D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[34] "SmTlf_enuState[34]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001286E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[35] "SmTlf_enuState[35]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001286F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[36] "SmTlf_enuState[36]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012870 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[37] "SmTlf_enuState[37]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012871 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[38] "SmTlf_enuState[38]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012872 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[39] "SmTlf_enuState[39]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012873 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[3] "SmTlf_enuState[3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001284F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[40] "SmTlf_enuState[40]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012874 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[41] "SmTlf_enuState[41]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012875 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[42] "SmTlf_enuState[42]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012876 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[43] "SmTlf_enuState[43]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012877 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[44] "SmTlf_enuState[44]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012878 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[45] "SmTlf_enuState[45]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012879 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[46] "SmTlf_enuState[46]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001287A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[47] "SmTlf_enuState[47]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001287B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[48] "SmTlf_enuState[48]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001287C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[49] "SmTlf_enuState[49]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001287D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[4] "SmTlf_enuState[4]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012850 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[50] "SmTlf_enuState[50]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001287E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[51] "SmTlf_enuState[51]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001287F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[52] "SmTlf_enuState[52]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012880 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[53] "SmTlf_enuState[53]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012881 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[54] "SmTlf_enuState[54]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012882 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[55] "SmTlf_enuState[55]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012883 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[56] "SmTlf_enuState[56]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012884 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[57] "SmTlf_enuState[57]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012885 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[58] "SmTlf_enuState[58]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012886 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[59] "SmTlf_enuState[59]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012887 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[5] "SmTlf_enuState[5]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012851 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[60] "SmTlf_enuState[60]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012888 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[61] "SmTlf_enuState[61]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012889 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[62] "SmTlf_enuState[62]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001288A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[63] "SmTlf_enuState[63]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001288B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[64] "SmTlf_enuState[64]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001288C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[65] "SmTlf_enuState[65]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001288D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[66] "SmTlf_enuState[66]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001288E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[67] "SmTlf_enuState[67]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001288F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[68] "SmTlf_enuState[68]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012890 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[69] "SmTlf_enuState[69]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012891 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[6] "SmTlf_enuState[6]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012852 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[70] "SmTlf_enuState[70]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012892 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[71] "SmTlf_enuState[71]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012893 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[72] "SmTlf_enuState[72]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012894 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[73] "SmTlf_enuState[73]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012895 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[74] "SmTlf_enuState[74]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012896 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[75] "SmTlf_enuState[75]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012897 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[76] "SmTlf_enuState[76]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012898 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[77] "SmTlf_enuState[77]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012899 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[78] "SmTlf_enuState[78]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001289A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[79] "SmTlf_enuState[79]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001289B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[7] "SmTlf_enuState[7]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012853 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[80] "SmTlf_enuState[80]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001289C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[81] "SmTlf_enuState[81]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001289D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[82] "SmTlf_enuState[82]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001289E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[83] "SmTlf_enuState[83]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001289F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[84] "SmTlf_enuState[84]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600128A0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[85] "SmTlf_enuState[85]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600128A1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[86] "SmTlf_enuState[86]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600128A2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[87] "SmTlf_enuState[87]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600128A3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[88] "SmTlf_enuState[88]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600128A4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[89] "SmTlf_enuState[89]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600128A5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[8] "SmTlf_enuState[8]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012854 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[90] "SmTlf_enuState[90]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600128A6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[91] "SmTlf_enuState[91]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600128A7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[92] "SmTlf_enuState[92]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600128A8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[93] "SmTlf_enuState[93]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600128A9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[94] "SmTlf_enuState[94]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600128AA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[95] "SmTlf_enuState[95]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600128AB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[96] "SmTlf_enuState[96]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600128AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[97] "SmTlf_enuState[97]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600128AD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[98] "SmTlf_enuState[98]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600128AE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[99] "SmTlf_enuState[99]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600128AF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SmTlf_enuState[9] "SmTlf_enuState[9]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012855 READ_WRITE /end MEASUREMENT
/begin COMPU_METHOD F_0v01_p0_4 "" RAT_FUNC "%9.2" "�s" COEFFS 0 1 0 0 0 0.01 /end COMPU_METHOD
/begin COMPU_METHOD I_5 "" RAT_FUNC "%9.2" "-" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD F_100_p0_22 "" RAT_FUNC "%9.2" "ms" COEFFS 0 1 0 0 0 100 /end COMPU_METHOD
/begin COMPU_METHOD F_m0v0000045_p100_23 "" RAT_FUNC "%9.6" "%" COEFFS 0 1 -100 0 0 -4.5e-006 /end COMPU_METHOD
/begin COMPU_METHOD F_0v4694835681_m284v9765258216_24 "" RAT_FUNC "%9.2" "�C" COEFFS 0 1 284.977 0 0 0.469484 /end COMPU_METHOD
/begin COMPU_METHOD F_1_p0_25 "" RAT_FUNC "%9.2" "Ms" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Id_0x00 "" RAT_FUNC "%9.2" "." COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Bool_ON_OFF "" TAB_VERB "%8.4" "." COMPU_TAB_REF Bool_ON_OFF_table /end COMPU_METHOD
/begin COMPU_VTAB Bool_ON_OFF_table "" TAB_VERB 2 0 "OFF" 1 "ON" /end COMPU_VTAB
/begin FUNCTION RSTSRV "" FUNCTION_VERSION "NONE_" /begin DEF_CHARACTERISTIC RSTSRV_ku16ConsecutiveRstMaxNbC /end DEF_CHARACTERISTIC
 /begin OUT_MEASUREMENT RSTSRV_bSWResetDetected RSTSRV_bSWResetDoneByPerformReset RSTSRV_enuRstSrc RSTSRV_u16ConsecutiveRstCtr RSTSRV_u16HotResetCtr RSTSRV_u16TimeAfterInit RSTSRV_u32ResetReason /end OUT_MEASUREMENT
/end FUNCTION
/begin FUNCTION RTMCLD ""
 /begin OUT_MEASUREMENT RTMCLD_u16MeasurementPeriodCounter RTMCLD_u32IdleClock RTMCLD_u32Load RTMCLD_u32PrevIdleClock /end OUT_MEASUREMENT
/end FUNCTION
/begin FUNCTION RTMTSK "" FUNCTION_VERSION "NONE_" /begin DEF_CHARACTERISTIC RTMTSK_ku8TaskId /end DEF_CHARACTERISTIC
 /begin OUT_MEASUREMENT RTMTSK_u32TaskDuration RTMTSK_u32TaskStartTime RTMTSK_u8TaskId /end OUT_MEASUREMENT
/end FUNCTION
/begin FUNCTION SAFEDGM ""
 /begin OUT_MEASUREMENT SAFEDGM_au32ErrsLedToRstPerGrp SAFEDGM_au32ErrsLedToRstPerGrp[0] SAFEDGM_au32ErrsLedToRstPerGrp[1] SAFEDGM_au32ErrsLedToRstPerGrp[2] SAFEDGM_au32ErrsLedToRstPerGrp[3] SAFEDGM_au32ErrsLedToRstPerGrp[4] SAFEDGM_au32ErrsLedToRstPerGrp[5] SAFEDGM_au32ErrsLedToRstPerGrp[6] SAFEDGM_au32ErrsLedToRstPerGrp[7] SAFEDGM_au32ErrsLedToRstPerGrp[8] SAFEDGM_au32ErrsPerGrp SAFEDGM_au32ErrsPerGrp[0] SAFEDGM_au32ErrsPerGrp[1] SAFEDGM_au32ErrsPerGrp[2] SAFEDGM_au32ErrsPerGrp[3] SAFEDGM_au32ErrsPerGrp[4] SAFEDGM_au32ErrsPerGrp[5] SAFEDGM_au32ErrsPerGrp[6] SAFEDGM_au32ErrsPerGrp[7] SAFEDGM_au32ErrsPerGrp[8] /end OUT_MEASUREMENT
/end FUNCTION
/begin FUNCTION SAFETSTM ""
 /begin OUT_MEASUREMENT SAFETSTM_astrStsLog[0].udtSlFlsTstEccErrPatChk SAFETSTM_astrStsLog[0].udtSlInit SAFETSTM_astrStsLog[0].udtSlPreInit SAFETSTM_astrStsLog[0].udtSlRun SAFETSTM_astrStsLog[0].udtSlTstsPreRun SAFETSTM_astrStsLog[0].udtSlTstsRun SAFETSTM_astrStsLog[0].udtUsrTstsPreRun SAFETSTM_astrStsLog[1].udtSlFlsTstEccErrPatChk SAFETSTM_astrStsLog[1].udtSlInit SAFETSTM_astrStsLog[1].udtSlPreInit SAFETSTM_astrStsLog[1].udtSlRun SAFETSTM_astrStsLog[1].udtSlTstsPreRun SAFETSTM_astrStsLog[1].udtSlTstsRun SAFETSTM_astrStsLog[1].udtUsrTstsPreRun SAFETSTM_astrStsLog[2].udtSlFlsTstEccErrPatChk SAFETSTM_astrStsLog[2].udtSlInit SAFETSTM_astrStsLog[2].udtSlPreInit SAFETSTM_astrStsLog[2].udtSlRun SAFETSTM_astrStsLog[2].udtSlTstsPreRun SAFETSTM_astrStsLog[2].udtSlTstsRun SAFETSTM_astrStsLog[2].udtUsrTstsPreRun SAFETSTM_audtSlPreRunTstsRsltCore0 SAFETSTM_audtSlPreRunTstsRsltCore0[0] SAFETSTM_audtSlPreRunTstsRsltCore0[10] SAFETSTM_audtSlPreRunTstsRsltCore0[11] SAFETSTM_audtSlPreRunTstsRsltCore0[1] SAFETSTM_audtSlPreRunTstsRsltCore0[2] SAFETSTM_audtSlPreRunTstsRsltCore0[3] SAFETSTM_audtSlPreRunTstsRsltCore0[4] SAFETSTM_audtSlPreRunTstsRsltCore0[5] SAFETSTM_audtSlPreRunTstsRsltCore0[6] SAFETSTM_audtSlPreRunTstsRsltCore0[7] SAFETSTM_audtSlPreRunTstsRsltCore0[8] SAFETSTM_audtSlPreRunTstsRsltCore0[9] SAFETSTM_audtSlPreRunTstsRsltCore1 SAFETSTM_audtSlPreRunTstsRsltCore1[0] SAFETSTM_audtSlPreRunTstsRsltCore1[10] SAFETSTM_audtSlPreRunTstsRsltCore1[11] SAFETSTM_audtSlPreRunTstsRsltCore1[1] SAFETSTM_audtSlPreRunTstsRsltCore1[2] SAFETSTM_audtSlPreRunTstsRsltCore1[3] SAFETSTM_audtSlPreRunTstsRsltCore1[4] SAFETSTM_audtSlPreRunTstsRsltCore1[5] SAFETSTM_audtSlPreRunTstsRsltCore1[6] SAFETSTM_audtSlPreRunTstsRsltCore1[7] SAFETSTM_audtSlPreRunTstsRsltCore1[8] SAFETSTM_audtSlPreRunTstsRsltCore1[9] SAFETSTM_audtSlPreRunTstsRsltCore2 SAFETSTM_audtSlPreRunTstsRsltCore2[0] SAFETSTM_audtSlPreRunTstsRsltCore2[10] SAFETSTM_audtSlPreRunTstsRsltCore2[11] SAFETSTM_audtSlPreRunTstsRsltCore2[1] SAFETSTM_audtSlPreRunTstsRsltCore2[2] SAFETSTM_audtSlPreRunTstsRsltCore2[3] SAFETSTM_audtSlPreRunTstsRsltCore2[4] SAFETSTM_audtSlPreRunTstsRsltCore2[5] SAFETSTM_audtSlPreRunTstsRsltCore2[6] SAFETSTM_audtSlPreRunTstsRsltCore2[7] SAFETSTM_audtSlPreRunTstsRsltCore2[8] SAFETSTM_audtSlPreRunTstsRsltCore2[9] /end OUT_MEASUREMENT
/end FUNCTION
/begin FUNCTION SAFEWDGM ""
 /begin OUT_MEASUREMENT SAFEWDGM_bDeinitRequest SAFEWDGM_bDisableRequest SAFEWDGM_bEnableRequest SAFEWDGM_bInitRequest SAFEWDGM_bReady SAFEWDGM_bResetRequest SAFEWDGM_bSleepRequest SAFEWDGM_bValidDeinitRequest SAFEWDGM_bValidDisableRequest SAFEWDGM_bValidEnableRequest SAFEWDGM_bValidInitRequest SAFEWDGM_bValidResetRequest SAFEWDGM_bValidSleepRequest SAFEWDGM_enuFailState SAFEWDGM_enuInactiveState SAFEWDGM_enuInitState SAFEWDGM_enuMainPhase SAFEWDGM_enuRunState SAFEWDGM_u8ActivateAttemptCntr SAFEWDGM_u8ActivateTimeoutCntr SAFEWDGM_u8DeactivateAttemptCntr SAFEWDGM_u8DeactivateTimeoutCntr SAFEWDGM_u8InitAttemptCntr SAFEWDGM_u8InitTimeoutCntr SAFEWDGM_u8RuntimeSlotIdx SAFEWDGM_u8State SAFEWDGM_u8WdgErrIncCntr SAFEWDGM_u8WdgNewErrCntr SAFEWDGM_u8WdgState SAFEWDGM_udtUserCmd[00].ReqCmd SAFEWDGM_udtUserCmd[00].UserData SAFEWDGM_udtUserCmd[01].ReqCmd SAFEWDGM_udtUserCmd[01].UserData SAFEWDGM_udtUserCmd[02].ReqCmd SAFEWDGM_udtUserCmd[02].UserData SAFEWDGM_udtUserCmd[03].ReqCmd SAFEWDGM_udtUserCmd[03].UserData SAFEWDGM_udtUserCmd[04].ReqCmd SAFEWDGM_udtUserCmd[04].UserData SAFEWDGM_udtUserCmd[05].ReqCmd SAFEWDGM_udtUserCmd[05].UserData SAFEWDGM_udtUserCmd[06].ReqCmd SAFEWDGM_udtUserCmd[06].UserData SAFEWDGM_udtUserCmd[07].ReqCmd SAFEWDGM_udtUserCmd[07].UserData SAFEWDGM_udtUserCmd[08].ReqCmd SAFEWDGM_udtUserCmd[08].UserData SAFEWDGM_udtUserCmd[09].ReqCmd SAFEWDGM_udtUserCmd[09].UserData SAFEWDGM_udtUserCmd[10].ReqCmd SAFEWDGM_udtUserCmd[10].UserData SAFEWDGM_udtUserCmd[11].ReqCmd SAFEWDGM_udtUserCmd[11].UserData SAFEWDGM_udtUserCmd[12].ReqCmd SAFEWDGM_udtUserCmd[12].UserData SAFEWDGM_udtUserCmd[13].ReqCmd SAFEWDGM_udtUserCmd[13].UserData SAFEWDGM_udtUserCmd[14].ReqCmd SAFEWDGM_udtUserCmd[14].UserData SAFEWDGM_udtUserCmd[15].ReqCmd SAFEWDGM_udtUserCmd[15].UserData SAFEWDGM_udtUserCmd[16].ReqCmd SAFEWDGM_udtUserCmd[16].UserData SAFEWDGM_udtUserCmd[17].ReqCmd SAFEWDGM_udtUserCmd[17].UserData SAFEWDGM_udtUserCmd[18].ReqCmd SAFEWDGM_udtUserCmd[18].UserData SAFEWDGM_udtUserCmd[19].ReqCmd SAFEWDGM_udtUserCmd[19].UserData SAFEWDGM_udtUserCmd[20].ReqCmd SAFEWDGM_udtUserCmd[20].UserData SAFEWDGM_udtUserCmd[21].ReqCmd SAFEWDGM_udtUserCmd[21].UserData SAFEWDGM_udtUserCmd[22].ReqCmd SAFEWDGM_udtUserCmd[22].UserData SAFEWDGM_udtUserCmd[23].ReqCmd SAFEWDGM_udtUserCmd[23].UserData SAFEWDGM_udtUserCmd[24].ReqCmd SAFEWDGM_udtUserCmd[24].UserData /end OUT_MEASUREMENT
/end FUNCTION
/begin FUNCTION SCU "" FUNCTION_VERSION "NONE_" /begin DEF_CHARACTERISTIC SCU_ku16MaxDieTempThrd SCU_ku16MinDieTempThrd /end DEF_CHARACTERISTIC /begin OUT_MEASUREMENT SCU_bDieFirstTemp SCU_u16DieTemp /end OUT_MEASUREMENT /end FUNCTION
/begin FUNCTION SPY ""
 /begin OUT_MEASUREMENT SPY_bBufFull SPY_u16DaqListFirstElmIdx SPY_u16NrOfElmsToTx SPY_u16PreTrigSmplIdx SPY_u16RmngSmplIdx SPY_u16SmplIdx SPY_u16TrigSmplIdx /end OUT_MEASUREMENT
/end FUNCTION
/begin FUNCTION STUB "" /begin DEF_CHARACTERISTIC STUB_ku32NvmWriteTimeOut /end DEF_CHARACTERISTIC /end FUNCTION
/begin FUNCTION SWTST "" FUNCTION_VERSION "NONE_"
 /begin OUT_MEASUREMENT SmTlf_enuState SmTlf_enuState[0] SmTlf_enuState[10] SmTlf_enuState[11] SmTlf_enuState[12] SmTlf_enuState[13] SmTlf_enuState[14] SmTlf_enuState[15] SmTlf_enuState[16] SmTlf_enuState[17] SmTlf_enuState[18] SmTlf_enuState[19] SmTlf_enuState[1] SmTlf_enuState[20] SmTlf_enuState[21] SmTlf_enuState[22] SmTlf_enuState[23] SmTlf_enuState[24] SmTlf_enuState[25] SmTlf_enuState[26] SmTlf_enuState[27] SmTlf_enuState[28] SmTlf_enuState[29] SmTlf_enuState[2] SmTlf_enuState[30] SmTlf_enuState[31] SmTlf_enuState[32] SmTlf_enuState[33] SmTlf_enuState[34] SmTlf_enuState[35] SmTlf_enuState[36] SmTlf_enuState[37] SmTlf_enuState[38] SmTlf_enuState[39] SmTlf_enuState[3] SmTlf_enuState[40] SmTlf_enuState[41] SmTlf_enuState[42] SmTlf_enuState[43] SmTlf_enuState[44] SmTlf_enuState[45] SmTlf_enuState[46] SmTlf_enuState[47] SmTlf_enuState[48] SmTlf_enuState[49] SmTlf_enuState[4] SmTlf_enuState[50] SmTlf_enuState[51] SmTlf_enuState[52] SmTlf_enuState[53] SmTlf_enuState[54] SmTlf_enuState[55] SmTlf_enuState[56] SmTlf_enuState[57] SmTlf_enuState[58] SmTlf_enuState[59] SmTlf_enuState[5] SmTlf_enuState[60] SmTlf_enuState[61] SmTlf_enuState[62] SmTlf_enuState[63] SmTlf_enuState[64] SmTlf_enuState[65] SmTlf_enuState[66] SmTlf_enuState[67] SmTlf_enuState[68] SmTlf_enuState[69] SmTlf_enuState[6] SmTlf_enuState[70] SmTlf_enuState[71] SmTlf_enuState[72] SmTlf_enuState[73] SmTlf_enuState[74] SmTlf_enuState[75] SmTlf_enuState[76] SmTlf_enuState[77] SmTlf_enuState[78] SmTlf_enuState[79] SmTlf_enuState[7] SmTlf_enuState[80] SmTlf_enuState[81] SmTlf_enuState[82] SmTlf_enuState[83] SmTlf_enuState[84] SmTlf_enuState[85] SmTlf_enuState[86] SmTlf_enuState[87] SmTlf_enuState[88] SmTlf_enuState[89] SmTlf_enuState[8] SmTlf_enuState[90] SmTlf_enuState[91] SmTlf_enuState[92] SmTlf_enuState[93] SmTlf_enuState[94] SmTlf_enuState[95] SmTlf_enuState[96] SmTlf_enuState[97] SmTlf_enuState[98] SmTlf_enuState[99] SmTlf_enuState[9] SWTST_au32SftyCurSafeSts SWTST_au32SftyCurSafeSts[0] SWTST_au32SftyCurSafeSts[1] SWTST_au32SftyCurSafeSts[2] SWTST_au32SftyCurSafeSts[3] SWTST_au32SftyCurSafeSts[4] SWTST_au32SftyCurSafeSts[5] SWTST_au32SftyCurSafeSts[6] SWTST_au32SftyCurSafeSts[7] SWTST_au32SftyPreSafeSts SWTST_au32SftyPreSafeSts[0] SWTST_au32SftyPreSafeSts[1] SWTST_au32SftyPreSafeSts[2] SWTST_au32SftyPreSafeSts[3] SWTST_au32SftyPreSafeSts[4] SWTST_au32SftyPreSafeSts[5] SWTST_au32SftyPreSafeSts[6] SWTST_au32SftyPreSafeSts[7] SWTST_au8ComRxMsg10Can1 SWTST_au8ComRxMsg10Can1[0] SWTST_au8ComRxMsg10Can1[1] SWTST_au8ComRxMsg10Can2 SWTST_au8ComRxMsg10Can2[0] SWTST_au8ComRxMsg10Can2[1] SWTST_au8ComRxMsg11Can1 SWTST_au8ComRxMsg11Can1[0] SWTST_au8ComRxMsg11Can1[1] SWTST_au8ComRxMsg11Can2 SWTST_au8ComRxMsg11Can2[0] SWTST_au8ComRxMsg11Can2[1] SWTST_au8ComRxMsg12Can1 SWTST_au8ComRxMsg12Can1[0] SWTST_au8ComRxMsg12Can1[1] SWTST_au8ComRxMsg12Can2 SWTST_au8ComRxMsg12Can2[0] SWTST_au8ComRxMsg12Can2[1] SWTST_au8ComRxMsg13Can1 SWTST_au8ComRxMsg13Can1[0] SWTST_au8ComRxMsg13Can1[1] SWTST_au8ComRxMsg13Can2 SWTST_au8ComRxMsg13Can2[0] SWTST_au8ComRxMsg13Can2[1] SWTST_au8ComRxMsg14Can1 SWTST_au8ComRxMsg14Can1[0] SWTST_au8ComRxMsg14Can1[1] SWTST_au8ComRxMsg14Can2 SWTST_au8ComRxMsg14Can2[0] SWTST_au8ComRxMsg14Can2[1] SWTST_au8ComRxMsg15Can1 SWTST_au8ComRxMsg15Can1[0] SWTST_au8ComRxMsg15Can1[1] SWTST_au8ComRxMsg15Can2 SWTST_au8ComRxMsg15Can2[0] SWTST_au8ComRxMsg15Can2[1] SWTST_au8ComRxMsg1Can1 SWTST_au8ComRxMsg1Can1[0] SWTST_au8ComRxMsg1Can1[1] SWTST_au8ComRxMsg1Can2 SWTST_au8ComRxMsg1Can2[0] SWTST_au8ComRxMsg1Can2[1] SWTST_au8ComRxMsg2Can1 SWTST_au8ComRxMsg2Can1[0] SWTST_au8ComRxMsg2Can1[1] SWTST_au8ComRxMsg2Can2 SWTST_au8ComRxMsg2Can2[0] SWTST_au8ComRxMsg2Can2[1] SWTST_au8ComRxMsg3Can1 SWTST_au8ComRxMsg3Can1[0] SWTST_au8ComRxMsg3Can1[1] SWTST_au8ComRxMsg3Can2 SWTST_au8ComRxMsg3Can2[0] SWTST_au8ComRxMsg3Can2[1] SWTST_au8ComRxMsg4Can1 SWTST_au8ComRxMsg4Can1[0] SWTST_au8ComRxMsg4Can1[1] SWTST_au8ComRxMsg4Can2 SWTST_au8ComRxMsg4Can2[0] SWTST_au8ComRxMsg4Can2[1] SWTST_au8ComRxMsg5Can1 SWTST_au8ComRxMsg5Can1[0] SWTST_au8ComRxMsg5Can1[1] SWTST_au8ComRxMsg5Can2 SWTST_au8ComRxMsg5Can2[0] SWTST_au8ComRxMsg5Can2[1] SWTST_au8ComRxMsg6Can1 SWTST_au8ComRxMsg6Can1[0] SWTST_au8ComRxMsg6Can1[1] SWTST_au8ComRxMsg6Can2 SWTST_au8ComRxMsg6Can2[0] SWTST_au8ComRxMsg6Can2[1] SWTST_au8ComRxMsg7Can1 SWTST_au8ComRxMsg7Can1[0] SWTST_au8ComRxMsg7Can1[1] SWTST_au8ComRxMsg7Can2 SWTST_au8ComRxMsg7Can2[0] SWTST_au8ComRxMsg7Can2[1] SWTST_au8ComRxMsg8Can1 SWTST_au8ComRxMsg8Can1[0] SWTST_au8ComRxMsg8Can1[1] SWTST_au8ComRxMsg8Can2 SWTST_au8ComRxMsg8Can2[0] SWTST_au8ComRxMsg8Can2[1] SWTST_au8ComRxMsg9Can1 SWTST_au8ComRxMsg9Can1[0] SWTST_au8ComRxMsg9Can1[1] SWTST_au8ComRxMsg9Can2 SWTST_au8ComRxMsg9Can2[0] SWTST_au8ComRxMsg9Can2[1] SWTST_au8ComTxMsg10Can1 SWTST_au8ComTxMsg10Can1[0] SWTST_au8ComTxMsg10Can1[1] SWTST_au8ComTxMsg10Can2 SWTST_au8ComTxMsg10Can2[0] SWTST_au8ComTxMsg10Can2[1] SWTST_au8ComTxMsg11Can1 SWTST_au8ComTxMsg11Can1[0] SWTST_au8ComTxMsg11Can1[1] SWTST_au8ComTxMsg11Can2 SWTST_au8ComTxMsg11Can2[0] SWTST_au8ComTxMsg11Can2[1] SWTST_au8ComTxMsg12Can1 SWTST_au8ComTxMsg12Can1[0] SWTST_au8ComTxMsg12Can1[1] SWTST_au8ComTxMsg12Can2 SWTST_au8ComTxMsg12Can2[0] SWTST_au8ComTxMsg12Can2[1] SWTST_au8ComTxMsg13Can1 SWTST_au8ComTxMsg13Can1[0] SWTST_au8ComTxMsg13Can1[1] SWTST_au8ComTxMsg13Can2 SWTST_au8ComTxMsg13Can2[0] SWTST_au8ComTxMsg13Can2[1] SWTST_au8ComTxMsg14Can1 SWTST_au8ComTxMsg14Can1[0] SWTST_au8ComTxMsg14Can1[1] SWTST_au8ComTxMsg14Can2 SWTST_au8ComTxMsg14Can2[0] SWTST_au8ComTxMsg14Can2[1] SWTST_au8ComTxMsg15Can1 SWTST_au8ComTxMsg15Can1[0] SWTST_au8ComTxMsg15Can1[1] SWTST_au8ComTxMsg15Can2 SWTST_au8ComTxMsg15Can2[0] SWTST_au8ComTxMsg15Can2[1] SWTST_au8ComTxMsg1Can1 SWTST_au8ComTxMsg1Can1[0] SWTST_au8ComTxMsg1Can1[1] SWTST_au8ComTxMsg1Can2 SWTST_au8ComTxMsg1Can2[0] SWTST_au8ComTxMsg1Can2[1] SWTST_au8ComTxMsg2Can1 SWTST_au8ComTxMsg2Can1[0] SWTST_au8ComTxMsg2Can1[1] SWTST_au8ComTxMsg2Can2 SWTST_au8ComTxMsg2Can2[0] SWTST_au8ComTxMsg2Can2[1] SWTST_au8ComTxMsg3Can1 SWTST_au8ComTxMsg3Can1[0] SWTST_au8ComTxMsg3Can1[1] SWTST_au8ComTxMsg3Can2 SWTST_au8ComTxMsg3Can2[0] SWTST_au8ComTxMsg3Can2[1] SWTST_au8ComTxMsg4Can1 SWTST_au8ComTxMsg4Can1[0] SWTST_au8ComTxMsg4Can1[1] SWTST_au8ComTxMsg4Can2 SWTST_au8ComTxMsg4Can2[0] SWTST_au8ComTxMsg4Can2[1] SWTST_au8ComTxMsg5Can1 SWTST_au8ComTxMsg5Can1[0] SWTST_au8ComTxMsg5Can1[1] SWTST_au8ComTxMsg5Can2 SWTST_au8ComTxMsg5Can2[0] SWTST_au8ComTxMsg5Can2[1] SWTST_au8ComTxMsg6Can1 SWTST_au8ComTxMsg6Can1[0] SWTST_au8ComTxMsg6Can1[1] SWTST_au8ComTxMsg6Can2 SWTST_au8ComTxMsg6Can2[0] SWTST_au8ComTxMsg6Can2[1] SWTST_au8ComTxMsg7Can1 SWTST_au8ComTxMsg7Can1[0] SWTST_au8ComTxMsg7Can1[1] SWTST_au8ComTxMsg7Can2 SWTST_au8ComTxMsg7Can2[0] SWTST_au8ComTxMsg7Can2[1] SWTST_au8ComTxMsg8Can1 SWTST_au8ComTxMsg8Can1[0] SWTST_au8ComTxMsg8Can1[1] SWTST_au8ComTxMsg8Can2 SWTST_au8ComTxMsg8Can2[0] SWTST_au8ComTxMsg8Can2[1] SWTST_au8ComTxMsg9Can1 SWTST_au8ComTxMsg9Can1[0] SWTST_au8ComTxMsg9Can1[1] SWTST_au8ComTxMsg9Can2 SWTST_au8ComTxMsg9Can2[0] SWTST_au8ComTxMsg9Can2[1] SWTST_au8FimDemEveStsHist SWTST_au8FimDemEveStsHist[0] SWTST_au8FimDemEveStsHist[100] SWTST_au8FimDemEveStsHist[101] SWTST_au8FimDemEveStsHist[102] SWTST_au8FimDemEveStsHist[103] SWTST_au8FimDemEveStsHist[104] SWTST_au8FimDemEveStsHist[105] SWTST_au8FimDemEveStsHist[106] SWTST_au8FimDemEveStsHist[107] SWTST_au8FimDemEveStsHist[108] SWTST_au8FimDemEveStsHist[109] SWTST_au8FimDemEveStsHist[10] SWTST_au8FimDemEveStsHist[110] SWTST_au8FimDemEveStsHist[111] SWTST_au8FimDemEveStsHist[112] SWTST_au8FimDemEveStsHist[113] SWTST_au8FimDemEveStsHist[114] SWTST_au8FimDemEveStsHist[115] SWTST_au8FimDemEveStsHist[116] SWTST_au8FimDemEveStsHist[117] SWTST_au8FimDemEveStsHist[118] SWTST_au8FimDemEveStsHist[119] SWTST_au8FimDemEveStsHist[11] SWTST_au8FimDemEveStsHist[120] SWTST_au8FimDemEveStsHist[121] SWTST_au8FimDemEveStsHist[122] SWTST_au8FimDemEveStsHist[123] SWTST_au8FimDemEveStsHist[124] SWTST_au8FimDemEveStsHist[125] SWTST_au8FimDemEveStsHist[126] SWTST_au8FimDemEveStsHist[127] SWTST_au8FimDemEveStsHist[128] SWTST_au8FimDemEveStsHist[129] SWTST_au8FimDemEveStsHist[12] SWTST_au8FimDemEveStsHist[130] SWTST_au8FimDemEveStsHist[131] SWTST_au8FimDemEveStsHist[132] SWTST_au8FimDemEveStsHist[133] SWTST_au8FimDemEveStsHist[134] SWTST_au8FimDemEveStsHist[135] SWTST_au8FimDemEveStsHist[136] SWTST_au8FimDemEveStsHist[137] SWTST_au8FimDemEveStsHist[138] SWTST_au8FimDemEveStsHist[139] SWTST_au8FimDemEveStsHist[13] SWTST_au8FimDemEveStsHist[140] SWTST_au8FimDemEveStsHist[141] SWTST_au8FimDemEveStsHist[142] SWTST_au8FimDemEveStsHist[143] SWTST_au8FimDemEveStsHist[144] SWTST_au8FimDemEveStsHist[145] SWTST_au8FimDemEveStsHist[146] SWTST_au8FimDemEveStsHist[147] SWTST_au8FimDemEveStsHist[148] SWTST_au8FimDemEveStsHist[149] SWTST_au8FimDemEveStsHist[14] SWTST_au8FimDemEveStsHist[150] SWTST_au8FimDemEveStsHist[151] SWTST_au8FimDemEveStsHist[152] SWTST_au8FimDemEveStsHist[153] SWTST_au8FimDemEveStsHist[154] SWTST_au8FimDemEveStsHist[155] SWTST_au8FimDemEveStsHist[156] SWTST_au8FimDemEveStsHist[157] SWTST_au8FimDemEveStsHist[158] SWTST_au8FimDemEveStsHist[159] SWTST_au8FimDemEveStsHist[15] SWTST_au8FimDemEveStsHist[160] SWTST_au8FimDemEveStsHist[161] SWTST_au8FimDemEveStsHist[162] SWTST_au8FimDemEveStsHist[163] SWTST_au8FimDemEveStsHist[164] SWTST_au8FimDemEveStsHist[165] SWTST_au8FimDemEveStsHist[166] SWTST_au8FimDemEveStsHist[167] SWTST_au8FimDemEveStsHist[168] SWTST_au8FimDemEveStsHist[169] SWTST_au8FimDemEveStsHist[16] SWTST_au8FimDemEveStsHist[170] SWTST_au8FimDemEveStsHist[171] SWTST_au8FimDemEveStsHist[172] SWTST_au8FimDemEveStsHist[173] SWTST_au8FimDemEveStsHist[174] SWTST_au8FimDemEveStsHist[175] SWTST_au8FimDemEveStsHist[176] SWTST_au8FimDemEveStsHist[177] SWTST_au8FimDemEveStsHist[178] SWTST_au8FimDemEveStsHist[179] SWTST_au8FimDemEveStsHist[17] SWTST_au8FimDemEveStsHist[180] SWTST_au8FimDemEveStsHist[181] SWTST_au8FimDemEveStsHist[182] SWTST_au8FimDemEveStsHist[183] SWTST_au8FimDemEveStsHist[184] SWTST_au8FimDemEveStsHist[185] SWTST_au8FimDemEveStsHist[186] SWTST_au8FimDemEveStsHist[187] SWTST_au8FimDemEveStsHist[188] SWTST_au8FimDemEveStsHist[189] SWTST_au8FimDemEveStsHist[18] SWTST_au8FimDemEveStsHist[190] SWTST_au8FimDemEveStsHist[191] SWTST_au8FimDemEveStsHist[192] SWTST_au8FimDemEveStsHist[193] SWTST_au8FimDemEveStsHist[194] SWTST_au8FimDemEveStsHist[195] SWTST_au8FimDemEveStsHist[196] SWTST_au8FimDemEveStsHist[197] SWTST_au8FimDemEveStsHist[198] SWTST_au8FimDemEveStsHist[199] SWTST_au8FimDemEveStsHist[19] SWTST_au8FimDemEveStsHist[1] SWTST_au8FimDemEveStsHist[200] SWTST_au8FimDemEveStsHist[201] SWTST_au8FimDemEveStsHist[202] SWTST_au8FimDemEveStsHist[203] SWTST_au8FimDemEveStsHist[204] SWTST_au8FimDemEveStsHist[205] SWTST_au8FimDemEveStsHist[206] SWTST_au8FimDemEveStsHist[207] SWTST_au8FimDemEveStsHist[208] SWTST_au8FimDemEveStsHist[209] SWTST_au8FimDemEveStsHist[20] SWTST_au8FimDemEveStsHist[210] SWTST_au8FimDemEveStsHist[211] SWTST_au8FimDemEveStsHist[212] SWTST_au8FimDemEveStsHist[213] SWTST_au8FimDemEveStsHist[214] SWTST_au8FimDemEveStsHist[215] SWTST_au8FimDemEveStsHist[216] SWTST_au8FimDemEveStsHist[217] SWTST_au8FimDemEveStsHist[218] SWTST_au8FimDemEveStsHist[219] SWTST_au8FimDemEveStsHist[21] SWTST_au8FimDemEveStsHist[220] SWTST_au8FimDemEveStsHist[221] SWTST_au8FimDemEveStsHist[222] SWTST_au8FimDemEveStsHist[223] SWTST_au8FimDemEveStsHist[224] SWTST_au8FimDemEveStsHist[225] SWTST_au8FimDemEveStsHist[226] SWTST_au8FimDemEveStsHist[227] SWTST_au8FimDemEveStsHist[228] SWTST_au8FimDemEveStsHist[229] SWTST_au8FimDemEveStsHist[22] SWTST_au8FimDemEveStsHist[230] SWTST_au8FimDemEveStsHist[231] SWTST_au8FimDemEveStsHist[232] SWTST_au8FimDemEveStsHist[233] SWTST_au8FimDemEveStsHist[234] SWTST_au8FimDemEveStsHist[235] SWTST_au8FimDemEveStsHist[236] SWTST_au8FimDemEveStsHist[237] SWTST_au8FimDemEveStsHist[238] SWTST_au8FimDemEveStsHist[239] SWTST_au8FimDemEveStsHist[23] SWTST_au8FimDemEveStsHist[240] SWTST_au8FimDemEveStsHist[241] SWTST_au8FimDemEveStsHist[242] SWTST_au8FimDemEveStsHist[243] SWTST_au8FimDemEveStsHist[244] SWTST_au8FimDemEveStsHist[245] SWTST_au8FimDemEveStsHist[246] SWTST_au8FimDemEveStsHist[247] SWTST_au8FimDemEveStsHist[248] SWTST_au8FimDemEveStsHist[249] SWTST_au8FimDemEveStsHist[24] SWTST_au8FimDemEveStsHist[250] SWTST_au8FimDemEveStsHist[251] SWTST_au8FimDemEveStsHist[252] SWTST_au8FimDemEveStsHist[253] SWTST_au8FimDemEveStsHist[254] SWTST_au8FimDemEveStsHist[255] SWTST_au8FimDemEveStsHist[256] SWTST_au8FimDemEveStsHist[257] SWTST_au8FimDemEveStsHist[258] SWTST_au8FimDemEveStsHist[259] SWTST_au8FimDemEveStsHist[25] SWTST_au8FimDemEveStsHist[260] SWTST_au8FimDemEveStsHist[261] SWTST_au8FimDemEveStsHist[262] SWTST_au8FimDemEveStsHist[263] SWTST_au8FimDemEveStsHist[264] SWTST_au8FimDemEveStsHist[265] SWTST_au8FimDemEveStsHist[266] SWTST_au8FimDemEveStsHist[267] SWTST_au8FimDemEveStsHist[268] SWTST_au8FimDemEveStsHist[269] SWTST_au8FimDemEveStsHist[26] SWTST_au8FimDemEveStsHist[270] SWTST_au8FimDemEveStsHist[271] SWTST_au8FimDemEveStsHist[272] SWTST_au8FimDemEveStsHist[273] SWTST_au8FimDemEveStsHist[274] SWTST_au8FimDemEveStsHist[275] SWTST_au8FimDemEveStsHist[276] SWTST_au8FimDemEveStsHist[277] SWTST_au8FimDemEveStsHist[278] SWTST_au8FimDemEveStsHist[279] SWTST_au8FimDemEveStsHist[27] SWTST_au8FimDemEveStsHist[280] SWTST_au8FimDemEveStsHist[281] SWTST_au8FimDemEveStsHist[282] SWTST_au8FimDemEveStsHist[283] SWTST_au8FimDemEveStsHist[284] SWTST_au8FimDemEveStsHist[285] SWTST_au8FimDemEveStsHist[286] SWTST_au8FimDemEveStsHist[287] SWTST_au8FimDemEveStsHist[288] SWTST_au8FimDemEveStsHist[289] SWTST_au8FimDemEveStsHist[28] SWTST_au8FimDemEveStsHist[290] SWTST_au8FimDemEveStsHist[291] SWTST_au8FimDemEveStsHist[292] SWTST_au8FimDemEveStsHist[293] SWTST_au8FimDemEveStsHist[294] SWTST_au8FimDemEveStsHist[295] SWTST_au8FimDemEveStsHist[296] SWTST_au8FimDemEveStsHist[297] SWTST_au8FimDemEveStsHist[298] SWTST_au8FimDemEveStsHist[299] SWTST_au8FimDemEveStsHist[29] SWTST_au8FimDemEveStsHist[2] SWTST_au8FimDemEveStsHist[300] SWTST_au8FimDemEveStsHist[301] SWTST_au8FimDemEveStsHist[302] SWTST_au8FimDemEveStsHist[303] SWTST_au8FimDemEveStsHist[304] SWTST_au8FimDemEveStsHist[305] SWTST_au8FimDemEveStsHist[306] SWTST_au8FimDemEveStsHist[307] SWTST_au8FimDemEveStsHist[308] SWTST_au8FimDemEveStsHist[309] SWTST_au8FimDemEveStsHist[30] SWTST_au8FimDemEveStsHist[310] SWTST_au8FimDemEveStsHist[311] SWTST_au8FimDemEveStsHist[312] SWTST_au8FimDemEveStsHist[313] SWTST_au8FimDemEveStsHist[314] SWTST_au8FimDemEveStsHist[315] SWTST_au8FimDemEveStsHist[316] SWTST_au8FimDemEveStsHist[317] SWTST_au8FimDemEveStsHist[318] SWTST_au8FimDemEveStsHist[319] SWTST_au8FimDemEveStsHist[31] SWTST_au8FimDemEveStsHist[320] SWTST_au8FimDemEveStsHist[321] SWTST_au8FimDemEveStsHist[322] SWTST_au8FimDemEveStsHist[323] SWTST_au8FimDemEveStsHist[324] SWTST_au8FimDemEveStsHist[325] SWTST_au8FimDemEveStsHist[326] SWTST_au8FimDemEveStsHist[327] SWTST_au8FimDemEveStsHist[328] SWTST_au8FimDemEveStsHist[329] SWTST_au8FimDemEveStsHist[32] SWTST_au8FimDemEveStsHist[330] SWTST_au8FimDemEveStsHist[331] SWTST_au8FimDemEveStsHist[332] SWTST_au8FimDemEveStsHist[333] SWTST_au8FimDemEveStsHist[334] SWTST_au8FimDemEveStsHist[335] SWTST_au8FimDemEveStsHist[336] SWTST_au8FimDemEveStsHist[337] SWTST_au8FimDemEveStsHist[338] SWTST_au8FimDemEveStsHist[339] SWTST_au8FimDemEveStsHist[33] SWTST_au8FimDemEveStsHist[340] SWTST_au8FimDemEveStsHist[341] SWTST_au8FimDemEveStsHist[342] SWTST_au8FimDemEveStsHist[343] SWTST_au8FimDemEveStsHist[344] SWTST_au8FimDemEveStsHist[345] SWTST_au8FimDemEveStsHist[346] SWTST_au8FimDemEveStsHist[347] SWTST_au8FimDemEveStsHist[348] SWTST_au8FimDemEveStsHist[349] SWTST_au8FimDemEveStsHist[34] SWTST_au8FimDemEveStsHist[350] SWTST_au8FimDemEveStsHist[351] SWTST_au8FimDemEveStsHist[352] SWTST_au8FimDemEveStsHist[353] SWTST_au8FimDemEveStsHist[354] SWTST_au8FimDemEveStsHist[35] SWTST_au8FimDemEveStsHist[36] SWTST_au8FimDemEveStsHist[37] SWTST_au8FimDemEveStsHist[38] SWTST_au8FimDemEveStsHist[39] SWTST_au8FimDemEveStsHist[3] SWTST_au8FimDemEveStsHist[40] SWTST_au8FimDemEveStsHist[41] SWTST_au8FimDemEveStsHist[42] SWTST_au8FimDemEveStsHist[43] SWTST_au8FimDemEveStsHist[44] SWTST_au8FimDemEveStsHist[45] SWTST_au8FimDemEveStsHist[46] SWTST_au8FimDemEveStsHist[47] SWTST_au8FimDemEveStsHist[48] SWTST_au8FimDemEveStsHist[49] SWTST_au8FimDemEveStsHist[4] SWTST_au8FimDemEveStsHist[50] SWTST_au8FimDemEveStsHist[51] SWTST_au8FimDemEveStsHist[52] SWTST_au8FimDemEveStsHist[53] SWTST_au8FimDemEveStsHist[54] SWTST_au8FimDemEveStsHist[55] SWTST_au8FimDemEveStsHist[56] SWTST_au8FimDemEveStsHist[57] SWTST_au8FimDemEveStsHist[58] SWTST_au8FimDemEveStsHist[59] SWTST_au8FimDemEveStsHist[5] SWTST_au8FimDemEveStsHist[60] SWTST_au8FimDemEveStsHist[61] SWTST_au8FimDemEveStsHist[62] SWTST_au8FimDemEveStsHist[63] SWTST_au8FimDemEveStsHist[64] SWTST_au8FimDemEveStsHist[65] SWTST_au8FimDemEveStsHist[66] SWTST_au8FimDemEveStsHist[67] SWTST_au8FimDemEveStsHist[68] SWTST_au8FimDemEveStsHist[69] SWTST_au8FimDemEveStsHist[6] SWTST_au8FimDemEveStsHist[70] SWTST_au8FimDemEveStsHist[71] SWTST_au8FimDemEveStsHist[72] SWTST_au8FimDemEveStsHist[73] SWTST_au8FimDemEveStsHist[74] SWTST_au8FimDemEveStsHist[75] SWTST_au8FimDemEveStsHist[76] SWTST_au8FimDemEveStsHist[77] SWTST_au8FimDemEveStsHist[78] SWTST_au8FimDemEveStsHist[79] SWTST_au8FimDemEveStsHist[7] SWTST_au8FimDemEveStsHist[80] SWTST_au8FimDemEveStsHist[81] SWTST_au8FimDemEveStsHist[82] SWTST_au8FimDemEveStsHist[83] SWTST_au8FimDemEveStsHist[84] SWTST_au8FimDemEveStsHist[85] SWTST_au8FimDemEveStsHist[86] SWTST_au8FimDemEveStsHist[87] SWTST_au8FimDemEveStsHist[88] SWTST_au8FimDemEveStsHist[89] SWTST_au8FimDemEveStsHist[8] SWTST_au8FimDemEveStsHist[90] SWTST_au8FimDemEveStsHist[91] SWTST_au8FimDemEveStsHist[92] SWTST_au8FimDemEveStsHist[93] SWTST_au8FimDemEveStsHist[94] SWTST_au8FimDemEveStsHist[95] SWTST_au8FimDemEveStsHist[96] SWTST_au8FimDemEveStsHist[97] SWTST_au8FimDemEveStsHist[98] SWTST_au8FimDemEveStsHist[99] SWTST_au8FimDemEveStsHist[9] SWTST_au8FimDemEveStsReal SWTST_au8FimDemEveStsReal[0] SWTST_au8FimDemEveStsReal[100] SWTST_au8FimDemEveStsReal[101] SWTST_au8FimDemEveStsReal[102] SWTST_au8FimDemEveStsReal[103] SWTST_au8FimDemEveStsReal[104] SWTST_au8FimDemEveStsReal[105] SWTST_au8FimDemEveStsReal[106] SWTST_au8FimDemEveStsReal[107] SWTST_au8FimDemEveStsReal[108] SWTST_au8FimDemEveStsReal[109] SWTST_au8FimDemEveStsReal[10] SWTST_au8FimDemEveStsReal[110] SWTST_au8FimDemEveStsReal[111] SWTST_au8FimDemEveStsReal[112] SWTST_au8FimDemEveStsReal[113] SWTST_au8FimDemEveStsReal[114] SWTST_au8FimDemEveStsReal[115] SWTST_au8FimDemEveStsReal[116] SWTST_au8FimDemEveStsReal[117] SWTST_au8FimDemEveStsReal[118] SWTST_au8FimDemEveStsReal[119] SWTST_au8FimDemEveStsReal[11] SWTST_au8FimDemEveStsReal[120] SWTST_au8FimDemEveStsReal[121] SWTST_au8FimDemEveStsReal[122] SWTST_au8FimDemEveStsReal[123] SWTST_au8FimDemEveStsReal[124] SWTST_au8FimDemEveStsReal[125] SWTST_au8FimDemEveStsReal[126] SWTST_au8FimDemEveStsReal[127] SWTST_au8FimDemEveStsReal[128] SWTST_au8FimDemEveStsReal[129] SWTST_au8FimDemEveStsReal[12] SWTST_au8FimDemEveStsReal[130] SWTST_au8FimDemEveStsReal[131] SWTST_au8FimDemEveStsReal[132] SWTST_au8FimDemEveStsReal[133] SWTST_au8FimDemEveStsReal[134] SWTST_au8FimDemEveStsReal[135] SWTST_au8FimDemEveStsReal[136] SWTST_au8FimDemEveStsReal[137] SWTST_au8FimDemEveStsReal[138] SWTST_au8FimDemEveStsReal[139] SWTST_au8FimDemEveStsReal[13] SWTST_au8FimDemEveStsReal[140] SWTST_au8FimDemEveStsReal[141] SWTST_au8FimDemEveStsReal[142] SWTST_au8FimDemEveStsReal[143] SWTST_au8FimDemEveStsReal[144] SWTST_au8FimDemEveStsReal[145] SWTST_au8FimDemEveStsReal[146] SWTST_au8FimDemEveStsReal[147] SWTST_au8FimDemEveStsReal[148] SWTST_au8FimDemEveStsReal[149] SWTST_au8FimDemEveStsReal[14] SWTST_au8FimDemEveStsReal[150] SWTST_au8FimDemEveStsReal[151] SWTST_au8FimDemEveStsReal[152] SWTST_au8FimDemEveStsReal[153] SWTST_au8FimDemEveStsReal[154] SWTST_au8FimDemEveStsReal[155] SWTST_au8FimDemEveStsReal[156] SWTST_au8FimDemEveStsReal[157] SWTST_au8FimDemEveStsReal[158] SWTST_au8FimDemEveStsReal[159] SWTST_au8FimDemEveStsReal[15] SWTST_au8FimDemEveStsReal[160] SWTST_au8FimDemEveStsReal[161] SWTST_au8FimDemEveStsReal[162] SWTST_au8FimDemEveStsReal[163] SWTST_au8FimDemEveStsReal[164] SWTST_au8FimDemEveStsReal[165] SWTST_au8FimDemEveStsReal[166] SWTST_au8FimDemEveStsReal[167] SWTST_au8FimDemEveStsReal[168] SWTST_au8FimDemEveStsReal[169] SWTST_au8FimDemEveStsReal[16] SWTST_au8FimDemEveStsReal[170] SWTST_au8FimDemEveStsReal[171] SWTST_au8FimDemEveStsReal[172] SWTST_au8FimDemEveStsReal[173] SWTST_au8FimDemEveStsReal[174] SWTST_au8FimDemEveStsReal[175] SWTST_au8FimDemEveStsReal[176] SWTST_au8FimDemEveStsReal[177] SWTST_au8FimDemEveStsReal[178] SWTST_au8FimDemEveStsReal[179] SWTST_au8FimDemEveStsReal[17] SWTST_au8FimDemEveStsReal[180] SWTST_au8FimDemEveStsReal[181] SWTST_au8FimDemEveStsReal[182] SWTST_au8FimDemEveStsReal[183] SWTST_au8FimDemEveStsReal[184] SWTST_au8FimDemEveStsReal[185] SWTST_au8FimDemEveStsReal[186] SWTST_au8FimDemEveStsReal[187] SWTST_au8FimDemEveStsReal[188] SWTST_au8FimDemEveStsReal[189] SWTST_au8FimDemEveStsReal[18] SWTST_au8FimDemEveStsReal[190] SWTST_au8FimDemEveStsReal[191] SWTST_au8FimDemEveStsReal[192] SWTST_au8FimDemEveStsReal[193] SWTST_au8FimDemEveStsReal[194] SWTST_au8FimDemEveStsReal[195] SWTST_au8FimDemEveStsReal[196] SWTST_au8FimDemEveStsReal[197] SWTST_au8FimDemEveStsReal[198] SWTST_au8FimDemEveStsReal[199] SWTST_au8FimDemEveStsReal[19] SWTST_au8FimDemEveStsReal[1] SWTST_au8FimDemEveStsReal[200] SWTST_au8FimDemEveStsReal[201] SWTST_au8FimDemEveStsReal[202] SWTST_au8FimDemEveStsReal[203] SWTST_au8FimDemEveStsReal[204] SWTST_au8FimDemEveStsReal[205] SWTST_au8FimDemEveStsReal[206] SWTST_au8FimDemEveStsReal[207] SWTST_au8FimDemEveStsReal[208] SWTST_au8FimDemEveStsReal[209] SWTST_au8FimDemEveStsReal[20] SWTST_au8FimDemEveStsReal[210] SWTST_au8FimDemEveStsReal[211] SWTST_au8FimDemEveStsReal[212] SWTST_au8FimDemEveStsReal[213] SWTST_au8FimDemEveStsReal[214] SWTST_au8FimDemEveStsReal[215] SWTST_au8FimDemEveStsReal[216] SWTST_au8FimDemEveStsReal[217] SWTST_au8FimDemEveStsReal[218] SWTST_au8FimDemEveStsReal[219] SWTST_au8FimDemEveStsReal[21] SWTST_au8FimDemEveStsReal[220] SWTST_au8FimDemEveStsReal[221] SWTST_au8FimDemEveStsReal[222] SWTST_au8FimDemEveStsReal[223] SWTST_au8FimDemEveStsReal[224] SWTST_au8FimDemEveStsReal[225] SWTST_au8FimDemEveStsReal[226] SWTST_au8FimDemEveStsReal[227] SWTST_au8FimDemEveStsReal[228] SWTST_au8FimDemEveStsReal[229] SWTST_au8FimDemEveStsReal[22] SWTST_au8FimDemEveStsReal[230] SWTST_au8FimDemEveStsReal[231] SWTST_au8FimDemEveStsReal[232] SWTST_au8FimDemEveStsReal[233] SWTST_au8FimDemEveStsReal[234] SWTST_au8FimDemEveStsReal[235] SWTST_au8FimDemEveStsReal[236] SWTST_au8FimDemEveStsReal[237] SWTST_au8FimDemEveStsReal[238] SWTST_au8FimDemEveStsReal[239] SWTST_au8FimDemEveStsReal[23] SWTST_au8FimDemEveStsReal[240] SWTST_au8FimDemEveStsReal[241] SWTST_au8FimDemEveStsReal[242] SWTST_au8FimDemEveStsReal[243] SWTST_au8FimDemEveStsReal[244] SWTST_au8FimDemEveStsReal[245] SWTST_au8FimDemEveStsReal[246] SWTST_au8FimDemEveStsReal[247] SWTST_au8FimDemEveStsReal[248] SWTST_au8FimDemEveStsReal[249] SWTST_au8FimDemEveStsReal[24] SWTST_au8FimDemEveStsReal[250] SWTST_au8FimDemEveStsReal[251] SWTST_au8FimDemEveStsReal[252] SWTST_au8FimDemEveStsReal[253] SWTST_au8FimDemEveStsReal[254] SWTST_au8FimDemEveStsReal[255] SWTST_au8FimDemEveStsReal[256] SWTST_au8FimDemEveStsReal[257] SWTST_au8FimDemEveStsReal[258] SWTST_au8FimDemEveStsReal[259] SWTST_au8FimDemEveStsReal[25] SWTST_au8FimDemEveStsReal[260] SWTST_au8FimDemEveStsReal[261] SWTST_au8FimDemEveStsReal[262] SWTST_au8FimDemEveStsReal[263] SWTST_au8FimDemEveStsReal[264] SWTST_au8FimDemEveStsReal[265] SWTST_au8FimDemEveStsReal[266] SWTST_au8FimDemEveStsReal[267] SWTST_au8FimDemEveStsReal[268] /end OUT_MEASUREMENT
/end FUNCTION
/begin COMPU_METHOD RSTSRV_enuRstSrc_conv "" TAB_VERB "%8.4" "." COMPU_TAB_REF RSTSRV_enuRstSrc_table /end COMPU_METHOD
/begin COMPU_VTAB RSTSRV_enuRstSrc_table "" TAB_VERB 18 0 "RSTSRV_enuESR0_RESET" 1 "RSTSRV_enuESR1_RESET" 2 "RSTSRV_enuSMU_RESET" 3 "RSTSRV_enuSW_RESET" 4 "RSTSRV_enuSTM0_RESET" 5 "RSTSRV_enuSTM1_RESET" 6 "RSTSRV_enuSTM2_RESET" 7 "RSTSRV_enuPOWER_ON_RESET" 8 "RSTSRV_enuCB0_RESET" 9 "RSTSRV_enuCB1_RESET" 10 "RSTSRV_enuCB3_RESET" 11 "RSTSRV_enuTP_RESET" 12 "RSTSRV_enuEVR13_RESET" 13 "RSTSRV_enuEVR33_RESET" 14 "RSTSRV_enuSUPPLY_WDOG_RESET" 15 "RSTSRV_enuSTBYR_RESET" 254 "RSTSRV_enuRESET_MULTIPLE" 255 "RSTSRV_enuRESET_UNDEFINED" /end COMPU_VTAB
/begin COMPU_METHOD SAFEWDGM_enuFailState_conv "" TAB_VERB "%8.4" "." COMPU_TAB_REF SAFEWDGM_enuFailState_table /end COMPU_METHOD
/begin COMPU_VTAB SAFEWDGM_enuFailState_table "" TAB_VERB 13 0 "SAFEWDGM_NO_FAIL" 1 "SAFEWDGM_INIT_FAIL" 2 "SAFEWDGM_ACTIVATE_FAIL" 3 "SAFEWDGM_RUN_FAIL_REPORT" 4 "SAFEWDGM_RUN_FAIL" 5 "SAFEWDGM_SLEEP_FAIL_REPORT" 6 "SAFEWDGM_SLEEP_FAIL" 7 "SAFEWDGM_DISABLE_FAIL_REPORT" 8 "SAFEWDGM_DISABLE_FAIL" 9 "SAFEWDGM_DEINIT_FAIL_REPORT" 10 "SAFEWDGM_DEINIT_FAIL" 11 "SAFEWDGM_MAJOR_FAIL_REPORT" 12 "SAFEWDGM_MAJOR_FAIL" /end COMPU_VTAB
/begin COMPU_METHOD SAFEWDGM_enuInactiveState_conv "" TAB_VERB "%8.4" "." COMPU_TAB_REF SAFEWDGM_enuInactiveState_table /end COMPU_METHOD
/begin COMPU_VTAB SAFEWDGM_enuInactiveState_table "" TAB_VERB 15 0 "SAFEWDGM_NO_ACTION" 1 "SAFEWDGM_SLEEP_REQUEST" 2 "SAFEWDGM_SLEEP_REQUEST_DELAYED" 3 "SAFEWDGM_SLEEP_WAIT" 4 "SAFEWDGM_SLEEP" 5 "SAFEWDGM_DISABLE_REQUEST" 6 "SAFEWDGM_DISABLE_REQUEST_DELAYED" 7 "SAFEWDGM_DISABLE_WAIT" 8 "SAFEWDGM_DISABLE" 9 "SAFEWDGM_DEINIT_REQUEST" 10 "SAFEWDGM_DEINIT_REQUEST_DISABLE_DELAYED" 11 "SAFEWDGM_DEINIT_REQUEST_DISABLE_WAIT" 12 "SAFEWDGM_DEINIT_REQUEST_DEINIT" 13 "SAFEWDGM_DEINIT_REQUEST_DEINIT_DELAYED" 14 "SAFEWDGM_DEINIT" /end COMPU_VTAB
/begin COMPU_METHOD SAFEWDGM_enuInitState_conv "" TAB_VERB "%8.4" "." COMPU_TAB_REF SAFEWDGM_enuInitState_table /end COMPU_METHOD
/begin COMPU_VTAB SAFEWDGM_enuInitState_table "" TAB_VERB 6 0 "SAFEWDGM_POWER_ON" 1 "SAFEWDGM_INIT" 2 "SAFEWDGM_INIT_WAITING" 3 "SAFEWDGM_ACTIVATE" 4 "SAFEWDGM_ACTIVATE_WAITING" 5 "SAFEWDGM_INIT_DONE" /end COMPU_VTAB
/begin COMPU_METHOD SAFEWDGM_enuMainPhase_conv "" TAB_VERB "%8.4" "." COMPU_TAB_REF SAFEWDGM_enuMainPhase_table /end COMPU_METHOD
/begin COMPU_VTAB SAFEWDGM_enuMainPhase_table "" TAB_VERB 4 0 "SAFEWDGM_INIT_PHASE" 1 "SAFEWDGM_RUN_PHASE" 2 "SAFEWDGM_INACTIVE_PHASE" 3 "SAFEWDGM_FAIL_PHASE" /end COMPU_VTAB
/begin COMPU_METHOD SAFEWDGM_enuRunState_conv "" TAB_VERB "%8.4" "." COMPU_TAB_REF SAFEWDGM_enuRunState_table /end COMPU_METHOD
/begin COMPU_VTAB SAFEWDGM_enuRunState_table "" TAB_VERB 2 0 "SAFEWDGM_RUN_ACTIVE" 1 "SAFEWDGM_RUN_INACTIVE" /end COMPU_VTAB
/end MODULE
/end PROJECT
