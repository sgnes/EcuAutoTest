ASAP2_VERSION 1 70
/begin PROJECT TEST_PROJECT "TEST_PROJECT"
/begin HEADER "TEST_PROJECT" PROJECT_NO D0 VERSION "3095.02" /end HEADER
/begin MODULE TEST_PROJECT "TestSupplier"
/begin MOD_COMMON "" DEPOSIT ABSOLUTE BYTE_ORDER MSB_LAST ALIGNMENT_BYTE 1 ALIGNMENT_WORD 2 ALIGNMENT_LONG 4 ALIGNMENT_INT64 1 ALIGNMENT_FLOAT32_IEEE 4 ALIGNMENT_FLOAT64_IEEE 8 /end MOD_COMMON
/begin MEASUREMENT SWTST_u8ComRdPtodeSa49EnggmntCnsntPTOEngAccssoryDrive1 "SWTST_u8ComRdPtodeSa49EnggmntCnsntPTOEngAccssoryDrive1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012392 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa49EnggmntCnsntPTOEngAccssoryDrive2 "SWTST_u8ComRdPtodeSa49EnggmntCnsntPTOEngAccssoryDrive2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012391 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa49EnggmntCnsntTrnsfrCsOtptShaftPTO "SWTST_u8ComRdPtodeSa49EnggmntCnsntTrnsfrCsOtptShaftPTO" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012390 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa49EnggmntStatusTransInputShaftPTO1 "SWTST_u8ComRdPtodeSa49EnggmntStatusTransInputShaftPTO1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001238F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa49EnggmntStatusTransInputShaftPTO2 "SWTST_u8ComRdPtodeSa49EnggmntStatusTransInputShaftPTO2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001238E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa49EnggmntStatusTransOutputShaftPTO "SWTST_u8ComRdPtodeSa49EnggmntStatusTransOutputShaftPTO" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001238D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa49EnggmntSttsPTOEngAccessoryDrive1 "SWTST_u8ComRdPtodeSa49EnggmntSttsPTOEngAccessoryDrive1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001238C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa49EnggmntSttsPTOEngAccessoryDrive2 "SWTST_u8ComRdPtodeSa49EnggmntSttsPTOEngAccessoryDrive2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001238B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa49EnggmntSttsTrnsfrCsOtputShaftPTO "SWTST_u8ComRdPtodeSa49EnggmntSttsTrnsfrCsOtputShaftPTO" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001238A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRcSa15RetarderCtrlMethod "SWTST_u8ComRdRcSa15RetarderCtrlMethod" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012389 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRcSa15RetarderLocation "SWTST_u8ComRdRcSa15RetarderLocation" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012388 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRcSa15RetarderType "SWTST_u8ComRdRcSa15RetarderType" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012387 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRcSa41RetarderCtrlMethod "SWTST_u8ComRdRcSa41RetarderCtrlMethod" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012386 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRcSa41RetarderLocation "SWTST_u8ComRdRcSa41RetarderLocation" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012385 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRcSa41RetarderType "SWTST_u8ComRdRcSa41RetarderType" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012384 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxBMSFailSa243RxBMSLifeSignal "SWTST_u8ComRdRxBMSFailSa243RxBMSLifeSignal" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012381 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxBMSFailSa243RxBatErr "SWTST_u8ComRdRxBMSFailSa243RxBatErr" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012383 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxBMSFailSa243RxBatPlugState "SWTST_u8ComRdRxBMSFailSa243RxBatPlugState" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012382 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxBMSMainParaSa243RxBMSRequst "SWTST_u8ComRdRxBMSMainParaSa243RxBMSRequst" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001237C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxBMSMainParaSa243RxBMSState "SWTST_u8ComRdRxBMSMainParaSa243RxBMSState" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001237B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxBMSMainParaSa243RxBatErrRank "SWTST_u8ComRdRxBMSMainParaSa243RxBatErrRank" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012380 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxBMSMainParaSa243RxBatHeatRelayState "SWTST_u8ComRdRxBMSMainParaSa243RxBatHeatRelayState" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001237F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxBMSMainParaSa243RxBatTotalNegRelayState "SWTST_u8ComRdRxBMSMainParaSa243RxBatTotalNegRelayState" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001237E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxBMSMainParaSa243RxBatTotalPosRelayState "SWTST_u8ComRdRxBMSMainParaSa243RxBatTotalPosRelayState" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001237D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxBrkPumpCtrlSa155Da255RxBrkPumpCtrlBrkPumpSta "SWTST_u8ComRdRxBrkPumpCtrlSa155Da255RxBrkPumpCtrlBrkPumpSta" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001237A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxBrkPumpCtrlSa155Da255RxBrkPumpCtrlCANSta "SWTST_u8ComRdRxBrkPumpCtrlSa155Da255RxBrkPumpCtrlCANSta" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012379 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxBrkPumpCtrlSa155Da255RxBrkPumpCtrlCurrent "SWTST_u8ComRdRxBrkPumpCtrlSa155Da255RxBrkPumpCtrlCurrent" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012378 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxBrkPumpCtrlSa155Da255RxBrkPumpCtrlErrCode "SWTST_u8ComRdRxBrkPumpCtrlSa155Da255RxBrkPumpCtrlErrCode" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012377 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxBrkPumpCtrlSa155Da255RxBrkPumpCtrlPreCharFed "SWTST_u8ComRdRxBrkPumpCtrlSa155Da255RxBrkPumpCtrlPreCharFed" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012376 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxCLUGearCmdSa05RxCLUCModeSwith "SWTST_u8ComRdRxCLUGearCmdSa05RxCLUCModeSwith" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012375 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxCLUGearCmdSa05RxCLUHandelSta "SWTST_u8ComRdRxCLUGearCmdSa05RxCLUHandelSta" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012374 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxDBStaVehSa23RxDBAlaBacPres "SWTST_u8ComRdRxDBStaVehSa23RxDBAlaBacPres" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012373 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxDBStaVehSa23RxDBAlaFroPres "SWTST_u8ComRdRxDBStaVehSa23RxDBAlaFroPres" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012372 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxDBStaVehSa23RxDBBacCabDoor "SWTST_u8ComRdRxDBStaVehSa23RxDBBacCabDoor" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012371 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxDBStaVehSa23RxDBMidDoor "SWTST_u8ComRdRxDBStaVehSa23RxDBMidDoor" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012370 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxDBStaVehSa23RxDBStaFroDoor "SWTST_u8ComRdRxDBStaVehSa23RxDBStaFroDoor" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001236F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxDBStaVehSa23RxDBVehON "SWTST_u8ComRdRxDBStaVehSa23RxDBVehON" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001236E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxDBStaVehSa23RxDBVehPKB "SWTST_u8ComRdRxDBStaVehSa23RxDBVehPKB" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001236D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxDBStaVehSa23RxDBVehStart "SWTST_u8ComRdRxDBStaVehSa23RxDBVehStart" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001236C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxDBStaVehSa23RxDBVehStop "SWTST_u8ComRdRxDBStaVehSa23RxDBVehStop" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001236B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxDCDCCtrl1Sa243RxDCDCCtrl1CNT "SWTST_u8ComRdRxDCDCCtrl1Sa243RxDCDCCtrl1CNT" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001236A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxDCDCCtrl1Sa243RxDCDCCtrl1ErrCode "SWTST_u8ComRdRxDCDCCtrl1Sa243RxDCDCCtrl1ErrCode" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012369 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxDCDCCtrl1Sa243RxDCDCCtrl1ErrRank "SWTST_u8ComRdRxDCDCCtrl1Sa243RxDCDCCtrl1ErrRank" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012368 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxDCDCCtrl1Sa243RxDCDCCtrl1WorkState "SWTST_u8ComRdRxDCDCCtrl1Sa243RxDCDCCtrl1WorkState" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012367 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxHVBoardSa209RxHVBoardEleAtt "SWTST_u8ComRdRxHVBoardSa209RxHVBoardEleAtt" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012366 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxHVBoardSa209RxHVBoardEleAttPreCharge "SWTST_u8ComRdRxHVBoardSa209RxHVBoardEleAttPreCharge" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012365 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxHVBoardSa209RxHVBoardMainMot "SWTST_u8ComRdRxHVBoardSa209RxHVBoardMainMot" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012364 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxHVBoardSa209RxHVBoardMainPreCharge "SWTST_u8ComRdRxHVBoardSa209RxHVBoardMainPreCharge" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012363 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxMCUStatus1Sa08RxMCUActDischaFedback "SWTST_u8ComRdRxMCUStatus1Sa08RxMCUActDischaFedback" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012362 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxMCUStatus1Sa08RxMCULiveCounter "SWTST_u8ComRdRxMCUStatus1Sa08RxMCULiveCounter" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012361 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxMCUStatus1Sa08RxMCUMotSta "SWTST_u8ComRdRxMCUStatus1Sa08RxMCUMotSta" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012360 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxMCUStatus1Sa08RxMCUMotWorkMode "SWTST_u8ComRdRxMCUStatus1Sa08RxMCUMotWorkMode" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001235F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxMCUStatus1Sa08RxMCUPreChargeAllow "SWTST_u8ComRdRxMCUStatus1Sa08RxMCUPreChargeAllow" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001235E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxMCUStatus2Sa08RxMCULiveCounter "SWTST_u8ComRdRxMCUStatus2Sa08RxMCULiveCounter" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001235D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxMCUStatus2Sa08RxMCUMotErrRank "SWTST_u8ComRdRxMCUStatus2Sa08RxMCUMotErrRank" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001235C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCCANErr "SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCCANErr" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001235B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCIPMErr "SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCIPMErr" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001235A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCOTempInvertWa "SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCOTempInvertWa" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012359 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCOTempWindWa "SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCOTempWindWa" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012358 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCOverCurr "SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCOverCurr" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012357 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCOverSpd "SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCOverSpd" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012356 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCOverTempInvert "SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCOverTempInvert" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012355 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCOverTempWind "SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCOverTempWind" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012354 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCOverVolt "SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCOverVolt" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012353 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCOverVoltWarn "SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCOverVoltWarn" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012352 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCResolverErr "SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCResolverErr" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012351 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCTempSensorWindErr "SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCTempSensorWindErr" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012350 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCUnderLowVolt "SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCUnderLowVolt" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001234F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCUnderVolt "SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCUnderVolt" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001234E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCUnderVoltWarn "SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCUnderVoltWarn" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001234D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxMCUStatus3Sa08RxMCULiveCounter "SWTST_u8ComRdRxMCUStatus3Sa08RxMCULiveCounter" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001234C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxMCUStatus3Sa08RxMCURotationCount "SWTST_u8ComRdRxMCUStatus3Sa08RxMCURotationCount" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001234B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxSteerPumpCtrlSa149Da255RxSteerPumpCtrlCANSta "SWTST_u8ComRdRxSteerPumpCtrlSa149Da255RxSteerPumpCtrlCANSta" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001234A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxSteerPumpCtrlSa149Da255RxSteerPumpCtrlCurrent "SWTST_u8ComRdRxSteerPumpCtrlSa149Da255RxSteerPumpCtrlCurrent" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012349 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxSteerPumpCtrlSa149Da255RxSteerPumpCtrlErrCode "SWTST_u8ComRdRxSteerPumpCtrlSa149Da255RxSteerPumpCtrlErrCode" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012348 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxSteerPumpCtrlSa149Da255RxSteerPumpCtrlNowCtrlledSta "SWTST_u8ComRdRxSteerPumpCtrlSa149Da255RxSteerPumpCtrlNowCtrlledSta" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012347 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxSteerPumpCtrlSa149Da255RxSteerPumpCtrlOilPumpSta "SWTST_u8ComRdRxSteerPumpCtrlSa149Da255RxSteerPumpCtrlOilPumpSta" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012346 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdRxSteerPumpCtrlSa149Da255RxSteerPumpCtrlPreCharFed "SWTST_u8ComRdRxSteerPumpCtrlSa149Da255RxSteerPumpCtrlPreCharFed" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012345 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05AutoNeutralReq "SWTST_u8ComRdTc1Sa05AutoNeutralReq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012344 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05Da255AutoNeutralReq "SWTST_u8ComRdTc1Sa05Da255AutoNeutralReq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012343 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05Da255DisengageDiffLockRqCentral "SWTST_u8ComRdTc1Sa05Da255DisengageDiffLockRqCentral" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012342 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05Da255DisengageDiffLockRqCentralFront "SWTST_u8ComRdTc1Sa05Da255DisengageDiffLockRqCentralFront" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012341 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05Da255DisengageDiffLockRqCentralRear "SWTST_u8ComRdTc1Sa05Da255DisengageDiffLockRqCentralRear" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012340 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05Da255DisengageDiffLockRqFrontAxle1 "SWTST_u8ComRdTc1Sa05Da255DisengageDiffLockRqFrontAxle1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001233F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05Da255DisengageDiffLockRqFrontAxle2 "SWTST_u8ComRdTc1Sa05Da255DisengageDiffLockRqFrontAxle2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001233E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05Da255DisengageDiffLockRqRearAxle1 "SWTST_u8ComRdTc1Sa05Da255DisengageDiffLockRqRearAxle1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001233D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05Da255DisengageDiffLockRqRearAxle2 "SWTST_u8ComRdTc1Sa05Da255DisengageDiffLockRqRearAxle2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001233C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05Da255DisengageDrivelineRq "SWTST_u8ComRdTc1Sa05Da255DisengageDrivelineRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001233B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05Da255TransGearShiftInhibitRq "SWTST_u8ComRdTc1Sa05Da255TransGearShiftInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001233A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05Da255TransLoadReductionInhibitRq "SWTST_u8ComRdTc1Sa05Da255TransLoadReductionInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012339 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05Da255TransMode1 "SWTST_u8ComRdTc1Sa05Da255TransMode1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012338 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05Da255TransMode2 "SWTST_u8ComRdTc1Sa05Da255TransMode2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012337 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05Da255TransMode3 "SWTST_u8ComRdTc1Sa05Da255TransMode3" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012336 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05Da255TransMode4 "SWTST_u8ComRdTc1Sa05Da255TransMode4" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012335 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05Da255TransMode5 "SWTST_u8ComRdTc1Sa05Da255TransMode5" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012334 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05Da255TransMode6 "SWTST_u8ComRdTc1Sa05Da255TransMode6" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012333 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05Da255TransMode7 "SWTST_u8ComRdTc1Sa05Da255TransMode7" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012332 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05Da255TransMode8 "SWTST_u8ComRdTc1Sa05Da255TransMode8" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012331 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05Da255TransRequestedLaunchGear "SWTST_u8ComRdTc1Sa05Da255TransRequestedLaunchGear" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012330 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05Da255TransReverseGearShiftInhibitRq "SWTST_u8ComRdTc1Sa05Da255TransReverseGearShiftInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001232F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05Da255TrnsShftSlectorDisplayModeSwitch "SWTST_u8ComRdTc1Sa05Da255TrnsShftSlectorDisplayModeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001232E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05Da255TrnsTrqeConverterLockupDisableRq "SWTST_u8ComRdTc1Sa05Da255TrnsTrqeConverterLockupDisableRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001232D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05DisengageDiffLockRqCentral "SWTST_u8ComRdTc1Sa05DisengageDiffLockRqCentral" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001232C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05DisengageDiffLockRqCentralFront "SWTST_u8ComRdTc1Sa05DisengageDiffLockRqCentralFront" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001232B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05DisengageDiffLockRqCentralRear "SWTST_u8ComRdTc1Sa05DisengageDiffLockRqCentralRear" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001232A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05DisengageDiffLockRqFrontAxle1 "SWTST_u8ComRdTc1Sa05DisengageDiffLockRqFrontAxle1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012329 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05DisengageDiffLockRqFrontAxle2 "SWTST_u8ComRdTc1Sa05DisengageDiffLockRqFrontAxle2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012328 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05DisengageDiffLockRqRearAxle1 "SWTST_u8ComRdTc1Sa05DisengageDiffLockRqRearAxle1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012327 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05DisengageDiffLockRqRearAxle2 "SWTST_u8ComRdTc1Sa05DisengageDiffLockRqRearAxle2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012326 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05DisengageDrivelineRq "SWTST_u8ComRdTc1Sa05DisengageDrivelineRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012325 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05TransGearShiftInhibitRq "SWTST_u8ComRdTc1Sa05TransGearShiftInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012324 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05TransLoadReductionInhibitRq "SWTST_u8ComRdTc1Sa05TransLoadReductionInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012323 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05TransMode1 "SWTST_u8ComRdTc1Sa05TransMode1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012322 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05TransMode2 "SWTST_u8ComRdTc1Sa05TransMode2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012321 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05TransMode3 "SWTST_u8ComRdTc1Sa05TransMode3" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012320 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05TransMode4 "SWTST_u8ComRdTc1Sa05TransMode4" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001231F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05TransMode5 "SWTST_u8ComRdTc1Sa05TransMode5" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001231E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05TransMode6 "SWTST_u8ComRdTc1Sa05TransMode6" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001231D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05TransMode7 "SWTST_u8ComRdTc1Sa05TransMode7" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001231C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05TransMode8 "SWTST_u8ComRdTc1Sa05TransMode8" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001231B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05TransRequestedLaunchGear "SWTST_u8ComRdTc1Sa05TransRequestedLaunchGear" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001231A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05TransReverseGearShiftInhibitRq "SWTST_u8ComRdTc1Sa05TransReverseGearShiftInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012319 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05TrnsShftSlectorDisplayModeSwitch "SWTST_u8ComRdTc1Sa05TrnsShftSlectorDisplayModeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012318 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa05TrnsTrqeConverterLockupDisableRq "SWTST_u8ComRdTc1Sa05TrnsTrqeConverterLockupDisableRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012317 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06AutoNeutralReq "SWTST_u8ComRdTc1Sa06AutoNeutralReq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012316 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06Da255AutoNeutralReq "SWTST_u8ComRdTc1Sa06Da255AutoNeutralReq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012315 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06Da255DisengageDiffLockRqCentral "SWTST_u8ComRdTc1Sa06Da255DisengageDiffLockRqCentral" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012314 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06Da255DisengageDiffLockRqCentralFront "SWTST_u8ComRdTc1Sa06Da255DisengageDiffLockRqCentralFront" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012313 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06Da255DisengageDiffLockRqCentralRear "SWTST_u8ComRdTc1Sa06Da255DisengageDiffLockRqCentralRear" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012312 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06Da255DisengageDiffLockRqFrontAxle1 "SWTST_u8ComRdTc1Sa06Da255DisengageDiffLockRqFrontAxle1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012311 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06Da255DisengageDiffLockRqFrontAxle2 "SWTST_u8ComRdTc1Sa06Da255DisengageDiffLockRqFrontAxle2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012310 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06Da255DisengageDiffLockRqRearAxle1 "SWTST_u8ComRdTc1Sa06Da255DisengageDiffLockRqRearAxle1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001230F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06Da255DisengageDiffLockRqRearAxle2 "SWTST_u8ComRdTc1Sa06Da255DisengageDiffLockRqRearAxle2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001230E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06Da255DisengageDrivelineRq "SWTST_u8ComRdTc1Sa06Da255DisengageDrivelineRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001230D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06Da255TransGearShiftInhibitRq "SWTST_u8ComRdTc1Sa06Da255TransGearShiftInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001230C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06Da255TransLoadReductionInhibitRq "SWTST_u8ComRdTc1Sa06Da255TransLoadReductionInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001230B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06Da255TransMode1 "SWTST_u8ComRdTc1Sa06Da255TransMode1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001230A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06Da255TransMode2 "SWTST_u8ComRdTc1Sa06Da255TransMode2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012309 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06Da255TransMode3 "SWTST_u8ComRdTc1Sa06Da255TransMode3" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012308 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06Da255TransMode4 "SWTST_u8ComRdTc1Sa06Da255TransMode4" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012307 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06Da255TransMode5 "SWTST_u8ComRdTc1Sa06Da255TransMode5" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012306 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06Da255TransMode6 "SWTST_u8ComRdTc1Sa06Da255TransMode6" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012305 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06Da255TransMode7 "SWTST_u8ComRdTc1Sa06Da255TransMode7" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012304 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06Da255TransMode8 "SWTST_u8ComRdTc1Sa06Da255TransMode8" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012303 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06Da255TransRequestedLaunchGear "SWTST_u8ComRdTc1Sa06Da255TransRequestedLaunchGear" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012302 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06Da255TransReverseGearShiftInhibitRq "SWTST_u8ComRdTc1Sa06Da255TransReverseGearShiftInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012301 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06Da255TrnsShftSlectorDisplayModeSwitch "SWTST_u8ComRdTc1Sa06Da255TrnsShftSlectorDisplayModeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012300 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06Da255TrnsTrqeConverterLockupDisableRq "SWTST_u8ComRdTc1Sa06Da255TrnsTrqeConverterLockupDisableRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122FF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06DisengageDiffLockRqCentral "SWTST_u8ComRdTc1Sa06DisengageDiffLockRqCentral" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122FE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06DisengageDiffLockRqCentralFront "SWTST_u8ComRdTc1Sa06DisengageDiffLockRqCentralFront" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122FD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06DisengageDiffLockRqCentralRear "SWTST_u8ComRdTc1Sa06DisengageDiffLockRqCentralRear" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122FC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06DisengageDiffLockRqFrontAxle1 "SWTST_u8ComRdTc1Sa06DisengageDiffLockRqFrontAxle1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122FB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06DisengageDiffLockRqFrontAxle2 "SWTST_u8ComRdTc1Sa06DisengageDiffLockRqFrontAxle2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122FA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06DisengageDiffLockRqRearAxle1 "SWTST_u8ComRdTc1Sa06DisengageDiffLockRqRearAxle1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122F9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06DisengageDiffLockRqRearAxle2 "SWTST_u8ComRdTc1Sa06DisengageDiffLockRqRearAxle2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122F8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06DisengageDrivelineRq "SWTST_u8ComRdTc1Sa06DisengageDrivelineRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122F7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06TransGearShiftInhibitRq "SWTST_u8ComRdTc1Sa06TransGearShiftInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122F6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06TransLoadReductionInhibitRq "SWTST_u8ComRdTc1Sa06TransLoadReductionInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122F5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06TransMode1 "SWTST_u8ComRdTc1Sa06TransMode1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122F4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06TransMode2 "SWTST_u8ComRdTc1Sa06TransMode2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122F3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06TransMode3 "SWTST_u8ComRdTc1Sa06TransMode3" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122F2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06TransMode4 "SWTST_u8ComRdTc1Sa06TransMode4" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122F1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06TransMode5 "SWTST_u8ComRdTc1Sa06TransMode5" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122F0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06TransMode6 "SWTST_u8ComRdTc1Sa06TransMode6" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122EF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06TransMode7 "SWTST_u8ComRdTc1Sa06TransMode7" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122EE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06TransMode8 "SWTST_u8ComRdTc1Sa06TransMode8" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122ED READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06TransRequestedLaunchGear "SWTST_u8ComRdTc1Sa06TransRequestedLaunchGear" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122EC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06TransReverseGearShiftInhibitRq "SWTST_u8ComRdTc1Sa06TransReverseGearShiftInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122EB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06TrnsShftSlectorDisplayModeSwitch "SWTST_u8ComRdTc1Sa06TrnsShftSlectorDisplayModeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122EA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa06TrnsTrqeConverterLockupDisableRq "SWTST_u8ComRdTc1Sa06TrnsTrqeConverterLockupDisableRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122E9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23AutoNeutralReq "SWTST_u8ComRdTc1Sa23AutoNeutralReq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122E8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23Da255AutoNeutralReq "SWTST_u8ComRdTc1Sa23Da255AutoNeutralReq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122E7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23Da255DisengageDiffLockRqCentral "SWTST_u8ComRdTc1Sa23Da255DisengageDiffLockRqCentral" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122E6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23Da255DisengageDiffLockRqCentralFront "SWTST_u8ComRdTc1Sa23Da255DisengageDiffLockRqCentralFront" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122E5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23Da255DisengageDiffLockRqCentralRear "SWTST_u8ComRdTc1Sa23Da255DisengageDiffLockRqCentralRear" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122E4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23Da255DisengageDiffLockRqFrontAxle1 "SWTST_u8ComRdTc1Sa23Da255DisengageDiffLockRqFrontAxle1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122E3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23Da255DisengageDiffLockRqFrontAxle2 "SWTST_u8ComRdTc1Sa23Da255DisengageDiffLockRqFrontAxle2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122E2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23Da255DisengageDiffLockRqRearAxle1 "SWTST_u8ComRdTc1Sa23Da255DisengageDiffLockRqRearAxle1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122E1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23Da255DisengageDiffLockRqRearAxle2 "SWTST_u8ComRdTc1Sa23Da255DisengageDiffLockRqRearAxle2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122E0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23Da255DisengageDrivelineRq "SWTST_u8ComRdTc1Sa23Da255DisengageDrivelineRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122DF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23Da255TransGearShiftInhibitRq "SWTST_u8ComRdTc1Sa23Da255TransGearShiftInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122DE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23Da255TransLoadReductionInhibitRq "SWTST_u8ComRdTc1Sa23Da255TransLoadReductionInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122DD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23Da255TransMode1 "SWTST_u8ComRdTc1Sa23Da255TransMode1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122DC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23Da255TransMode2 "SWTST_u8ComRdTc1Sa23Da255TransMode2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122DB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23Da255TransMode3 "SWTST_u8ComRdTc1Sa23Da255TransMode3" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122DA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23Da255TransMode4 "SWTST_u8ComRdTc1Sa23Da255TransMode4" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122D9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23Da255TransMode5 "SWTST_u8ComRdTc1Sa23Da255TransMode5" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122D8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23Da255TransMode6 "SWTST_u8ComRdTc1Sa23Da255TransMode6" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122D7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23Da255TransMode7 "SWTST_u8ComRdTc1Sa23Da255TransMode7" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122D6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23Da255TransMode8 "SWTST_u8ComRdTc1Sa23Da255TransMode8" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122D5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23Da255TransRequestedLaunchGear "SWTST_u8ComRdTc1Sa23Da255TransRequestedLaunchGear" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122D4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23Da255TransReverseGearShiftInhibitRq "SWTST_u8ComRdTc1Sa23Da255TransReverseGearShiftInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122D3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23Da255TrnsShftSlectorDisplayModeSwitch "SWTST_u8ComRdTc1Sa23Da255TrnsShftSlectorDisplayModeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122D2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23Da255TrnsTrqeConverterLockupDisableRq "SWTST_u8ComRdTc1Sa23Da255TrnsTrqeConverterLockupDisableRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122D1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23DisengageDiffLockRqCentral "SWTST_u8ComRdTc1Sa23DisengageDiffLockRqCentral" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122D0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23DisengageDiffLockRqCentralFront "SWTST_u8ComRdTc1Sa23DisengageDiffLockRqCentralFront" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122CF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23DisengageDiffLockRqCentralRear "SWTST_u8ComRdTc1Sa23DisengageDiffLockRqCentralRear" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122CE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23DisengageDiffLockRqFrontAxle1 "SWTST_u8ComRdTc1Sa23DisengageDiffLockRqFrontAxle1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122CD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23DisengageDiffLockRqFrontAxle2 "SWTST_u8ComRdTc1Sa23DisengageDiffLockRqFrontAxle2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122CC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23DisengageDiffLockRqRearAxle1 "SWTST_u8ComRdTc1Sa23DisengageDiffLockRqRearAxle1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122CB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23DisengageDiffLockRqRearAxle2 "SWTST_u8ComRdTc1Sa23DisengageDiffLockRqRearAxle2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122CA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23DisengageDrivelineRq "SWTST_u8ComRdTc1Sa23DisengageDrivelineRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122C9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23TransGearShiftInhibitRq "SWTST_u8ComRdTc1Sa23TransGearShiftInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122C8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23TransLoadReductionInhibitRq "SWTST_u8ComRdTc1Sa23TransLoadReductionInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122C7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23TransMode1 "SWTST_u8ComRdTc1Sa23TransMode1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122C6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23TransMode2 "SWTST_u8ComRdTc1Sa23TransMode2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122C5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23TransMode3 "SWTST_u8ComRdTc1Sa23TransMode3" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122C4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23TransMode4 "SWTST_u8ComRdTc1Sa23TransMode4" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122C3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23TransMode5 "SWTST_u8ComRdTc1Sa23TransMode5" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122C2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23TransMode6 "SWTST_u8ComRdTc1Sa23TransMode6" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122C1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23TransMode7 "SWTST_u8ComRdTc1Sa23TransMode7" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122C0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23TransMode8 "SWTST_u8ComRdTc1Sa23TransMode8" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122BF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23TransRequestedLaunchGear "SWTST_u8ComRdTc1Sa23TransRequestedLaunchGear" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122BE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23TransReverseGearShiftInhibitRq "SWTST_u8ComRdTc1Sa23TransReverseGearShiftInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122BD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23TrnsShftSlectorDisplayModeSwitch "SWTST_u8ComRdTc1Sa23TrnsShftSlectorDisplayModeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122BC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa23TrnsTrqeConverterLockupDisableRq "SWTST_u8ComRdTc1Sa23TrnsTrqeConverterLockupDisableRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122BB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33AutoNeutralReq "SWTST_u8ComRdTc1Sa33AutoNeutralReq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122BA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33Da255AutoNeutralReq "SWTST_u8ComRdTc1Sa33Da255AutoNeutralReq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122B9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33Da255DisengageDiffLockRqCentral "SWTST_u8ComRdTc1Sa33Da255DisengageDiffLockRqCentral" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122B8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33Da255DisengageDiffLockRqCentralFront "SWTST_u8ComRdTc1Sa33Da255DisengageDiffLockRqCentralFront" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122B7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33Da255DisengageDiffLockRqCentralRear "SWTST_u8ComRdTc1Sa33Da255DisengageDiffLockRqCentralRear" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122B6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33Da255DisengageDiffLockRqFrontAxle1 "SWTST_u8ComRdTc1Sa33Da255DisengageDiffLockRqFrontAxle1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122B5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33Da255DisengageDiffLockRqFrontAxle2 "SWTST_u8ComRdTc1Sa33Da255DisengageDiffLockRqFrontAxle2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122B4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33Da255DisengageDiffLockRqRearAxle1 "SWTST_u8ComRdTc1Sa33Da255DisengageDiffLockRqRearAxle1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122B3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33Da255DisengageDiffLockRqRearAxle2 "SWTST_u8ComRdTc1Sa33Da255DisengageDiffLockRqRearAxle2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122B2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33Da255DisengageDrivelineRq "SWTST_u8ComRdTc1Sa33Da255DisengageDrivelineRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122B1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33Da255TransGearShiftInhibitRq "SWTST_u8ComRdTc1Sa33Da255TransGearShiftInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122B0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33Da255TransLoadReductionInhibitRq "SWTST_u8ComRdTc1Sa33Da255TransLoadReductionInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122AF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33Da255TransMode1 "SWTST_u8ComRdTc1Sa33Da255TransMode1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122AE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33Da255TransMode2 "SWTST_u8ComRdTc1Sa33Da255TransMode2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122AD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33Da255TransMode3 "SWTST_u8ComRdTc1Sa33Da255TransMode3" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33Da255TransMode4 "SWTST_u8ComRdTc1Sa33Da255TransMode4" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122AB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33Da255TransMode5 "SWTST_u8ComRdTc1Sa33Da255TransMode5" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122AA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33Da255TransMode6 "SWTST_u8ComRdTc1Sa33Da255TransMode6" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122A9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33Da255TransMode7 "SWTST_u8ComRdTc1Sa33Da255TransMode7" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122A8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33Da255TransMode8 "SWTST_u8ComRdTc1Sa33Da255TransMode8" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122A7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33Da255TransRequestedLaunchGear "SWTST_u8ComRdTc1Sa33Da255TransRequestedLaunchGear" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122A6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33Da255TransReverseGearShiftInhibitRq "SWTST_u8ComRdTc1Sa33Da255TransReverseGearShiftInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122A5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33Da255TrnsShftSlectorDisplayModeSwitch "SWTST_u8ComRdTc1Sa33Da255TrnsShftSlectorDisplayModeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122A4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33Da255TrnsTrqeConverterLockupDisableRq "SWTST_u8ComRdTc1Sa33Da255TrnsTrqeConverterLockupDisableRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122A3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33DisengageDiffLockRqCentral "SWTST_u8ComRdTc1Sa33DisengageDiffLockRqCentral" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122A2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33DisengageDiffLockRqCentralFront "SWTST_u8ComRdTc1Sa33DisengageDiffLockRqCentralFront" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122A1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33DisengageDiffLockRqCentralRear "SWTST_u8ComRdTc1Sa33DisengageDiffLockRqCentralRear" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600122A0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33DisengageDiffLockRqFrontAxle1 "SWTST_u8ComRdTc1Sa33DisengageDiffLockRqFrontAxle1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001229F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33DisengageDiffLockRqFrontAxle2 "SWTST_u8ComRdTc1Sa33DisengageDiffLockRqFrontAxle2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001229E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33DisengageDiffLockRqRearAxle1 "SWTST_u8ComRdTc1Sa33DisengageDiffLockRqRearAxle1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001229D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33DisengageDiffLockRqRearAxle2 "SWTST_u8ComRdTc1Sa33DisengageDiffLockRqRearAxle2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001229C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33DisengageDrivelineRq "SWTST_u8ComRdTc1Sa33DisengageDrivelineRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001229B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33TransGearShiftInhibitRq "SWTST_u8ComRdTc1Sa33TransGearShiftInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001229A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33TransLoadReductionInhibitRq "SWTST_u8ComRdTc1Sa33TransLoadReductionInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012299 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33TransMode1 "SWTST_u8ComRdTc1Sa33TransMode1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012298 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33TransMode2 "SWTST_u8ComRdTc1Sa33TransMode2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012297 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33TransMode3 "SWTST_u8ComRdTc1Sa33TransMode3" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012296 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33TransMode4 "SWTST_u8ComRdTc1Sa33TransMode4" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012295 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33TransMode5 "SWTST_u8ComRdTc1Sa33TransMode5" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012294 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33TransMode6 "SWTST_u8ComRdTc1Sa33TransMode6" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012293 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33TransMode7 "SWTST_u8ComRdTc1Sa33TransMode7" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012292 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33TransMode8 "SWTST_u8ComRdTc1Sa33TransMode8" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012291 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33TransRequestedLaunchGear "SWTST_u8ComRdTc1Sa33TransRequestedLaunchGear" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012290 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33TransReverseGearShiftInhibitRq "SWTST_u8ComRdTc1Sa33TransReverseGearShiftInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001228F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33TrnsShftSlectorDisplayModeSwitch "SWTST_u8ComRdTc1Sa33TrnsShftSlectorDisplayModeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001228E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa33TrnsTrqeConverterLockupDisableRq "SWTST_u8ComRdTc1Sa33TrnsTrqeConverterLockupDisableRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001228D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42AutoNeutralReq "SWTST_u8ComRdTc1Sa42AutoNeutralReq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001228C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42Da255AutoNeutralReq "SWTST_u8ComRdTc1Sa42Da255AutoNeutralReq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001228B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42Da255DisengageDiffLockRqCentral "SWTST_u8ComRdTc1Sa42Da255DisengageDiffLockRqCentral" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001228A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42Da255DisengageDiffLockRqCentralFront "SWTST_u8ComRdTc1Sa42Da255DisengageDiffLockRqCentralFront" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012289 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42Da255DisengageDiffLockRqCentralRear "SWTST_u8ComRdTc1Sa42Da255DisengageDiffLockRqCentralRear" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012288 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42Da255DisengageDiffLockRqFrontAxle1 "SWTST_u8ComRdTc1Sa42Da255DisengageDiffLockRqFrontAxle1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012287 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42Da255DisengageDiffLockRqFrontAxle2 "SWTST_u8ComRdTc1Sa42Da255DisengageDiffLockRqFrontAxle2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012286 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42Da255DisengageDiffLockRqRearAxle1 "SWTST_u8ComRdTc1Sa42Da255DisengageDiffLockRqRearAxle1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012285 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42Da255DisengageDiffLockRqRearAxle2 "SWTST_u8ComRdTc1Sa42Da255DisengageDiffLockRqRearAxle2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012284 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42Da255DisengageDrivelineRq "SWTST_u8ComRdTc1Sa42Da255DisengageDrivelineRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012283 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42Da255TransGearShiftInhibitRq "SWTST_u8ComRdTc1Sa42Da255TransGearShiftInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012282 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42Da255TransLoadReductionInhibitRq "SWTST_u8ComRdTc1Sa42Da255TransLoadReductionInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012281 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42Da255TransMode1 "SWTST_u8ComRdTc1Sa42Da255TransMode1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012280 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42Da255TransMode2 "SWTST_u8ComRdTc1Sa42Da255TransMode2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001227F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42Da255TransMode3 "SWTST_u8ComRdTc1Sa42Da255TransMode3" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001227E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42Da255TransMode4 "SWTST_u8ComRdTc1Sa42Da255TransMode4" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001227D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42Da255TransMode5 "SWTST_u8ComRdTc1Sa42Da255TransMode5" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001227C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42Da255TransMode6 "SWTST_u8ComRdTc1Sa42Da255TransMode6" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001227B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42Da255TransMode7 "SWTST_u8ComRdTc1Sa42Da255TransMode7" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001227A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42Da255TransMode8 "SWTST_u8ComRdTc1Sa42Da255TransMode8" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012279 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42Da255TransRequestedLaunchGear "SWTST_u8ComRdTc1Sa42Da255TransRequestedLaunchGear" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012278 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42Da255TransReverseGearShiftInhibitRq "SWTST_u8ComRdTc1Sa42Da255TransReverseGearShiftInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012277 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42Da255TrnsShftSlectorDisplayModeSwitch "SWTST_u8ComRdTc1Sa42Da255TrnsShftSlectorDisplayModeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012276 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42Da255TrnsTrqeConverterLockupDisableRq "SWTST_u8ComRdTc1Sa42Da255TrnsTrqeConverterLockupDisableRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012275 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42DisengageDiffLockRqCentral "SWTST_u8ComRdTc1Sa42DisengageDiffLockRqCentral" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012274 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42DisengageDiffLockRqCentralFront "SWTST_u8ComRdTc1Sa42DisengageDiffLockRqCentralFront" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012273 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42DisengageDiffLockRqCentralRear "SWTST_u8ComRdTc1Sa42DisengageDiffLockRqCentralRear" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012272 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42DisengageDiffLockRqFrontAxle1 "SWTST_u8ComRdTc1Sa42DisengageDiffLockRqFrontAxle1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012271 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42DisengageDiffLockRqFrontAxle2 "SWTST_u8ComRdTc1Sa42DisengageDiffLockRqFrontAxle2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012270 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42DisengageDiffLockRqRearAxle1 "SWTST_u8ComRdTc1Sa42DisengageDiffLockRqRearAxle1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001226F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42DisengageDiffLockRqRearAxle2 "SWTST_u8ComRdTc1Sa42DisengageDiffLockRqRearAxle2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001226E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42DisengageDrivelineRq "SWTST_u8ComRdTc1Sa42DisengageDrivelineRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001226D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42TransGearShiftInhibitRq "SWTST_u8ComRdTc1Sa42TransGearShiftInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001226C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42TransLoadReductionInhibitRq "SWTST_u8ComRdTc1Sa42TransLoadReductionInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001226B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42TransMode1 "SWTST_u8ComRdTc1Sa42TransMode1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001226A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42TransMode2 "SWTST_u8ComRdTc1Sa42TransMode2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012269 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42TransMode3 "SWTST_u8ComRdTc1Sa42TransMode3" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012268 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42TransMode4 "SWTST_u8ComRdTc1Sa42TransMode4" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012267 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42TransMode5 "SWTST_u8ComRdTc1Sa42TransMode5" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012266 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42TransMode6 "SWTST_u8ComRdTc1Sa42TransMode6" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012265 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42TransMode7 "SWTST_u8ComRdTc1Sa42TransMode7" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012264 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42TransMode8 "SWTST_u8ComRdTc1Sa42TransMode8" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012263 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42TransRequestedLaunchGear "SWTST_u8ComRdTc1Sa42TransRequestedLaunchGear" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012262 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42TransReverseGearShiftInhibitRq "SWTST_u8ComRdTc1Sa42TransReverseGearShiftInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012261 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42TrnsShftSlectorDisplayModeSwitch "SWTST_u8ComRdTc1Sa42TrnsShftSlectorDisplayModeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012260 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa42TrnsTrqeConverterLockupDisableRq "SWTST_u8ComRdTc1Sa42TrnsTrqeConverterLockupDisableRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001225F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49AutoNeutralReq "SWTST_u8ComRdTc1Sa49AutoNeutralReq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001225E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49Da255AutoNeutralReq "SWTST_u8ComRdTc1Sa49Da255AutoNeutralReq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001225D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49Da255DisengageDiffLockRqCentral "SWTST_u8ComRdTc1Sa49Da255DisengageDiffLockRqCentral" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001225C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49Da255DisengageDiffLockRqCentralFront "SWTST_u8ComRdTc1Sa49Da255DisengageDiffLockRqCentralFront" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001225B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49Da255DisengageDiffLockRqCentralRear "SWTST_u8ComRdTc1Sa49Da255DisengageDiffLockRqCentralRear" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001225A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49Da255DisengageDiffLockRqFrontAxle1 "SWTST_u8ComRdTc1Sa49Da255DisengageDiffLockRqFrontAxle1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012259 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49Da255DisengageDiffLockRqFrontAxle2 "SWTST_u8ComRdTc1Sa49Da255DisengageDiffLockRqFrontAxle2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012258 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49Da255DisengageDiffLockRqRearAxle1 "SWTST_u8ComRdTc1Sa49Da255DisengageDiffLockRqRearAxle1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012257 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49Da255DisengageDiffLockRqRearAxle2 "SWTST_u8ComRdTc1Sa49Da255DisengageDiffLockRqRearAxle2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012256 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49Da255DisengageDrivelineRq "SWTST_u8ComRdTc1Sa49Da255DisengageDrivelineRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012255 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49Da255TransGearShiftInhibitRq "SWTST_u8ComRdTc1Sa49Da255TransGearShiftInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012254 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49Da255TransLoadReductionInhibitRq "SWTST_u8ComRdTc1Sa49Da255TransLoadReductionInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012253 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49Da255TransMode1 "SWTST_u8ComRdTc1Sa49Da255TransMode1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012252 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49Da255TransMode2 "SWTST_u8ComRdTc1Sa49Da255TransMode2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012251 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49Da255TransMode3 "SWTST_u8ComRdTc1Sa49Da255TransMode3" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012250 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49Da255TransMode4 "SWTST_u8ComRdTc1Sa49Da255TransMode4" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001224F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49Da255TransMode5 "SWTST_u8ComRdTc1Sa49Da255TransMode5" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001224E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49Da255TransMode6 "SWTST_u8ComRdTc1Sa49Da255TransMode6" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001224D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49Da255TransMode7 "SWTST_u8ComRdTc1Sa49Da255TransMode7" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001224C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49Da255TransMode8 "SWTST_u8ComRdTc1Sa49Da255TransMode8" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001224B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49Da255TransRequestedLaunchGear "SWTST_u8ComRdTc1Sa49Da255TransRequestedLaunchGear" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001224A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49Da255TransReverseGearShiftInhibitRq "SWTST_u8ComRdTc1Sa49Da255TransReverseGearShiftInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012249 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49Da255TrnsShftSlectorDisplayModeSwitch "SWTST_u8ComRdTc1Sa49Da255TrnsShftSlectorDisplayModeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012248 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49Da255TrnsTrqeConverterLockupDisableRq "SWTST_u8ComRdTc1Sa49Da255TrnsTrqeConverterLockupDisableRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012247 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49DisengageDiffLockRqCentral "SWTST_u8ComRdTc1Sa49DisengageDiffLockRqCentral" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012246 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49DisengageDiffLockRqCentralFront "SWTST_u8ComRdTc1Sa49DisengageDiffLockRqCentralFront" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012245 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49DisengageDiffLockRqCentralRear "SWTST_u8ComRdTc1Sa49DisengageDiffLockRqCentralRear" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012244 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49DisengageDiffLockRqFrontAxle1 "SWTST_u8ComRdTc1Sa49DisengageDiffLockRqFrontAxle1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012243 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49DisengageDiffLockRqFrontAxle2 "SWTST_u8ComRdTc1Sa49DisengageDiffLockRqFrontAxle2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012242 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49DisengageDiffLockRqRearAxle1 "SWTST_u8ComRdTc1Sa49DisengageDiffLockRqRearAxle1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012241 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49DisengageDiffLockRqRearAxle2 "SWTST_u8ComRdTc1Sa49DisengageDiffLockRqRearAxle2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012240 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49DisengageDrivelineRq "SWTST_u8ComRdTc1Sa49DisengageDrivelineRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001223F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49TransGearShiftInhibitRq "SWTST_u8ComRdTc1Sa49TransGearShiftInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001223E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49TransLoadReductionInhibitRq "SWTST_u8ComRdTc1Sa49TransLoadReductionInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001223D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49TransMode1 "SWTST_u8ComRdTc1Sa49TransMode1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001223C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49TransMode2 "SWTST_u8ComRdTc1Sa49TransMode2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001223B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49TransMode3 "SWTST_u8ComRdTc1Sa49TransMode3" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001223A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49TransMode4 "SWTST_u8ComRdTc1Sa49TransMode4" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012239 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49TransMode5 "SWTST_u8ComRdTc1Sa49TransMode5" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012238 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49TransMode6 "SWTST_u8ComRdTc1Sa49TransMode6" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012237 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49TransMode7 "SWTST_u8ComRdTc1Sa49TransMode7" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012236 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49TransMode8 "SWTST_u8ComRdTc1Sa49TransMode8" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012235 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49TransRequestedLaunchGear "SWTST_u8ComRdTc1Sa49TransRequestedLaunchGear" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012234 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49TransReverseGearShiftInhibitRq "SWTST_u8ComRdTc1Sa49TransReverseGearShiftInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012233 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49TrnsShftSlectorDisplayModeSwitch "SWTST_u8ComRdTc1Sa49TrnsShftSlectorDisplayModeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012232 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTc1Sa49TrnsTrqeConverterLockupDisableRq "SWTST_u8ComRdTc1Sa49TrnsTrqeConverterLockupDisableRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012231 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa00EngOverrideCtrlMode "SWTST_u8ComRdTsc1Sa00EngOverrideCtrlMode" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012230 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa00EngRequestedSpeedCtrlConditions "SWTST_u8ComRdTsc1Sa00EngRequestedSpeedCtrlConditions" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001222F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa00MessageChecksum "SWTST_u8ComRdTsc1Sa00MessageChecksum" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001222E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa00MessageCounter "SWTST_u8ComRdTsc1Sa00MessageCounter" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001222D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa00OverrideCtrlModePriority "SWTST_u8ComRdTsc1Sa00OverrideCtrlModePriority" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001222C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa00TSC1CtrlPurpose "SWTST_u8ComRdTsc1Sa00TSC1CtrlPurpose" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001222B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa00TSC1TransRate "SWTST_u8ComRdTsc1Sa00TSC1TransRate" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001222A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa11EngOverrideCtrlMode "SWTST_u8ComRdTsc1Sa11EngOverrideCtrlMode" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012229 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa11EngRequestedSpeedCtrlConditions "SWTST_u8ComRdTsc1Sa11EngRequestedSpeedCtrlConditions" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012228 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa11MessageChecksum "SWTST_u8ComRdTsc1Sa11MessageChecksum" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012227 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa11MessageCounter "SWTST_u8ComRdTsc1Sa11MessageCounter" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012226 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa11OverrideCtrlModePriority "SWTST_u8ComRdTsc1Sa11OverrideCtrlModePriority" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012225 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa11TSC1CtrlPurpose "SWTST_u8ComRdTsc1Sa11TSC1CtrlPurpose" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012224 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa11TSC1TransRate "SWTST_u8ComRdTsc1Sa11TSC1TransRate" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012223 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa17EngOverrideCtrlMode "SWTST_u8ComRdTsc1Sa17EngOverrideCtrlMode" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012222 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa17EngRequestedSpeedCtrlConditions "SWTST_u8ComRdTsc1Sa17EngRequestedSpeedCtrlConditions" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012221 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa17MessageChecksum "SWTST_u8ComRdTsc1Sa17MessageChecksum" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012220 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa17MessageCounter "SWTST_u8ComRdTsc1Sa17MessageCounter" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001221F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa17OverrideCtrlModePriority "SWTST_u8ComRdTsc1Sa17OverrideCtrlModePriority" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001221E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa17TSC1CtrlPurpose "SWTST_u8ComRdTsc1Sa17TSC1CtrlPurpose" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001221D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa17TSC1TransRate "SWTST_u8ComRdTsc1Sa17TSC1TransRate" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001221C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa33EngOverrideCtrlMode "SWTST_u8ComRdTsc1Sa33EngOverrideCtrlMode" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001221B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa33EngRequestedSpeedCtrlConditions "SWTST_u8ComRdTsc1Sa33EngRequestedSpeedCtrlConditions" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001221A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa33MessageChecksum "SWTST_u8ComRdTsc1Sa33MessageChecksum" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012219 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa33MessageCounter "SWTST_u8ComRdTsc1Sa33MessageCounter" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012218 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa33OverrideCtrlModePriority "SWTST_u8ComRdTsc1Sa33OverrideCtrlModePriority" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012217 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa33TSC1CtrlPurpose "SWTST_u8ComRdTsc1Sa33TSC1CtrlPurpose" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012216 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa33TSC1TransRate "SWTST_u8ComRdTsc1Sa33TSC1TransRate" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012215 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa39EngOverrideCtrlMode "SWTST_u8ComRdTsc1Sa39EngOverrideCtrlMode" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012214 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa39EngRequestedSpeedCtrlConditions "SWTST_u8ComRdTsc1Sa39EngRequestedSpeedCtrlConditions" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012213 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa39MessageChecksum "SWTST_u8ComRdTsc1Sa39MessageChecksum" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012212 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa39MessageCounter "SWTST_u8ComRdTsc1Sa39MessageCounter" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012211 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa39OverrideCtrlModePriority "SWTST_u8ComRdTsc1Sa39OverrideCtrlModePriority" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012210 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa39TSC1CtrlPurpose "SWTST_u8ComRdTsc1Sa39TSC1CtrlPurpose" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001220F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa39TSC1TransRate "SWTST_u8ComRdTsc1Sa39TSC1TransRate" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001220E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa42EngOverrideCtrlMode "SWTST_u8ComRdTsc1Sa42EngOverrideCtrlMode" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001220D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa42EngRequestedSpeedCtrlConditions "SWTST_u8ComRdTsc1Sa42EngRequestedSpeedCtrlConditions" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001220C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa42MessageChecksum "SWTST_u8ComRdTsc1Sa42MessageChecksum" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001220B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa42MessageCounter "SWTST_u8ComRdTsc1Sa42MessageCounter" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001220A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa42OverrideCtrlModePriority "SWTST_u8ComRdTsc1Sa42OverrideCtrlModePriority" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012209 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa42TSC1CtrlPurpose "SWTST_u8ComRdTsc1Sa42TSC1CtrlPurpose" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012208 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdTsc1Sa42TSC1TransRate "SWTST_u8ComRdTsc1Sa42TSC1TransRate" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012207 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComResumeTstNr "SWTST_u8ComResumeTstNr" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012206 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComTstDoneNr "SWTST_u8ComTstDoneNr" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012205 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComTstErrId "SWTST_u8ComTstErrId" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012204 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComTstNrNm1 "SWTST_u8ComTstNrNm1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012203 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DcmInfotype04RespFlag "SWTST_u8DcmInfotype04RespFlag" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012202 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DcmInfotype06RespFlag "SWTST_u8DcmInfotype06RespFlag" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012201 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DcmInfotype0ARespFlag "SWTST_u8DcmInfotype0ARespFlag" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012200 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcAnIptFltTst "SWTST_u8DiagcAnIptFltTst" UBYTE I_5 1 2 0 255 MATRIX_DIM 9 2 1 ECU_ADDRESS 0x600121EE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcAnIptFltTst[0][0] "SWTST_u8DiagcAnIptFltTst[0][0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121EE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcAnIptFltTst[0][1] "SWTST_u8DiagcAnIptFltTst[0][1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121EF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcAnIptFltTst[0][2] "SWTST_u8DiagcAnIptFltTst[0][2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121F0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcAnIptFltTst[0][3] "SWTST_u8DiagcAnIptFltTst[0][3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121F1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcAnIptFltTst[0][4] "SWTST_u8DiagcAnIptFltTst[0][4]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121F2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcAnIptFltTst[0][5] "SWTST_u8DiagcAnIptFltTst[0][5]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121F3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcAnIptFltTst[0][6] "SWTST_u8DiagcAnIptFltTst[0][6]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121F4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcAnIptFltTst[0][7] "SWTST_u8DiagcAnIptFltTst[0][7]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121F5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcAnIptFltTst[0][8] "SWTST_u8DiagcAnIptFltTst[0][8]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121F6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcAnIptFltTst[1][0] "SWTST_u8DiagcAnIptFltTst[1][0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121F7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcAnIptFltTst[1][1] "SWTST_u8DiagcAnIptFltTst[1][1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121F8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcAnIptFltTst[1][2] "SWTST_u8DiagcAnIptFltTst[1][2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121F9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcAnIptFltTst[1][3] "SWTST_u8DiagcAnIptFltTst[1][3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121FA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcAnIptFltTst[1][4] "SWTST_u8DiagcAnIptFltTst[1][4]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121FB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcAnIptFltTst[1][5] "SWTST_u8DiagcAnIptFltTst[1][5]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121FC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcAnIptFltTst[1][6] "SWTST_u8DiagcAnIptFltTst[1][6]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121FD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcAnIptFltTst[1][7] "SWTST_u8DiagcAnIptFltTst[1][7]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121FE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcAnIptFltTst[1][8] "SWTST_u8DiagcAnIptFltTst[1][8]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121FF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcBRAKE_AND_ABS "SWTST_u8DiagcBRAKE_AND_ABS" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121ED READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcCAN1BusOff "SWTST_u8DiagcCAN1BusOff" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121EC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcCAN2BusOff "SWTST_u8DiagcCAN2BusOff" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121EB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcCAN3BusOff "SWTST_u8DiagcCAN3BusOff" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121EA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcCCVS1_RX_SA_00ErrValDiagc "SWTST_u8DiagcCCVS1_RX_SA_00ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121E8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcCCVS1_RX_SA_00_SPN84ErrValDiagc "SWTST_u8DiagcCCVS1_RX_SA_00_SPN84ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121E9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcCCVS1_RX_SA_17_SPN84ErrValDiagc "SWTST_u8DiagcCCVS1_RX_SA_17_SPN84ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121E7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcCCVS1_RX_SA_232_SPN84ErrValDiagc "SWTST_u8DiagcCCVS1_RX_SA_232_SPN84ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121E5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcCCVS1_RX_SA_23_SPN84ErrValDiagc "SWTST_u8DiagcCCVS1_RX_SA_23_SPN84ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121E6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcCCVS1_RX_SA_33_SPN84ErrValDiagc "SWTST_u8DiagcCCVS1_RX_SA_33_SPN84ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121E4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcCCVS1_RX_SA_39_SPN84ErrValDiagc "SWTST_u8DiagcCCVS1_RX_SA_39_SPN84ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121E3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcCCVS1_RX_SA_49_SPN84ErrValDiagc "SWTST_u8DiagcCCVS1_RX_SA_49_SPN84ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121E2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcCheckSumTst "SWTST_u8DiagcCheckSumTst" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121E1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcEBC1_RX_SA_00SigErrValDiagc "SWTST_u8DiagcEBC1_RX_SA_00SigErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121DF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcEBC1_RX_SA_00_SPN521ErrValDiagc "SWTST_u8DiagcEBC1_RX_SA_00_SPN521ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121E0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcEBC1_RX_SA_11_SPN521ErrValDiagc "SWTST_u8DiagcEBC1_RX_SA_11_SPN521ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121DE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcEBC1_RX_SA_23_SPN521ErrValDiagc "SWTST_u8DiagcEBC1_RX_SA_23_SPN521ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121DD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcEBC1_RX_SA_33_SPN521ErrValDiagc "SWTST_u8DiagcEBC1_RX_SA_33_SPN521ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121DC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcEBC1_RX_SA_49_SPN521ErrValDiagc "SWTST_u8DiagcEBC1_RX_SA_49_SPN521ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121DB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcEC1_RX_SA_00ErrValDiagc544 "SWTST_u8DiagcEC1_RX_SA_00ErrValDiagc544" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121D9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcEC1_RX_SA_00_SPN544ErrValDiagc "SWTST_u8DiagcEC1_RX_SA_00_SPN544ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121DA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcEEC1_RX_SA_00ErrValDiagc "SWTST_u8DiagcEEC1_RX_SA_00ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121D6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcEEC1_RX_SA_00ErrValDiagc513 "SWTST_u8DiagcEEC1_RX_SA_00ErrValDiagc513" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121D5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcEEC1_RX_SA_00_SPN190ErrValDiagc "SWTST_u8DiagcEEC1_RX_SA_00_SPN190ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121D8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcEEC1_RX_SA_00_SPN513ErrValDiagc "SWTST_u8DiagcEEC1_RX_SA_00_SPN513ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121D7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcEEC2_RX_SA_00ErrValDiagc29 "SWTST_u8DiagcEEC2_RX_SA_00ErrValDiagc29" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121D2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcEEC2_RX_SA_00ErrValDiagc91 "SWTST_u8DiagcEEC2_RX_SA_00ErrValDiagc91" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121D1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcEEC2_RX_SA_00_SPN29ErrValDiagc "SWTST_u8DiagcEEC2_RX_SA_00_SPN29ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121D4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcEEC2_RX_SA_00_SPN91ErrValDiagc "SWTST_u8DiagcEEC2_RX_SA_00_SPN91ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121D3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcEEC2_RX_SA_17_SPN29ErrValDiagc "SWTST_u8DiagcEEC2_RX_SA_17_SPN29ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121D0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcEEC2_RX_SA_17_SPN91ErrValDiagc "SWTST_u8DiagcEEC2_RX_SA_17_SPN91ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121CF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcEEC2_RX_SA_33_SPN29ErrValDiagc "SWTST_u8DiagcEEC2_RX_SA_33_SPN29ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121CE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcEEC2_RX_SA_33_SPN91ErrValDiagc "SWTST_u8DiagcEEC2_RX_SA_33_SPN91ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121CD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcEEC2_RX_SA_49_SPN29ErrValDiagc "SWTST_u8DiagcEEC2_RX_SA_49_SPN29ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121CC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcEEC2_RX_SA_49_SPN91ErrValDiagc "SWTST_u8DiagcEEC2_RX_SA_49_SPN91ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121CB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcENGINE_COOLANT "SWTST_u8DiagcENGINE_COOLANT" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121C9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcENGINE_SPEED "SWTST_u8DiagcENGINE_SPEED" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121C8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcENGINE_TORQUE513 "SWTST_u8DiagcENGINE_TORQUE513" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121C7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcENGINE_TORQUE544 "SWTST_u8DiagcENGINE_TORQUE544" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121C6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcERC1_RX_SA_00ErrValDiagc1716 "SWTST_u8DiagcERC1_RX_SA_00ErrValDiagc1716" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121C2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcERC1_RX_SA_00ErrValDiagc520 "SWTST_u8DiagcERC1_RX_SA_00ErrValDiagc520" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121C1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcERC1_RX_SA_00ErrValDiagc571 "SWTST_u8DiagcERC1_RX_SA_00ErrValDiagc571" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121C0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcERC1_RX_SA_00_SPN1716ErrValDiagc "SWTST_u8DiagcERC1_RX_SA_00_SPN1716ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121C5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcERC1_RX_SA_00_SPN520ErrValDiagc "SWTST_u8DiagcERC1_RX_SA_00_SPN520ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121C4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcERC1_RX_SA_00_SPN571ErrValDiagc "SWTST_u8DiagcERC1_RX_SA_00_SPN571ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121C3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcERC1_RX_SA_15_SPN1716ErrValDiagc "SWTST_u8DiagcERC1_RX_SA_15_SPN1716ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121BF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcERC1_RX_SA_15_SPN520ErrValDiagc "SWTST_u8DiagcERC1_RX_SA_15_SPN520ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121BE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcERC1_RX_SA_15_SPN571ErrValDiagc "SWTST_u8DiagcERC1_RX_SA_15_SPN571ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121BD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcERC1_RX_SA_23_SPN1716ErrValDiagc "SWTST_u8DiagcERC1_RX_SA_23_SPN1716ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121BC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcERC1_RX_SA_23_SPN520ErrValDiagc "SWTST_u8DiagcERC1_RX_SA_23_SPN520ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121BB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcERC1_RX_SA_23_SPN571ErrValDiagc "SWTST_u8DiagcERC1_RX_SA_23_SPN571ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121BA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcERC1_RX_SA_33_SPN1716ErrValDiagc "SWTST_u8DiagcERC1_RX_SA_33_SPN1716ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121B9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcERC1_RX_SA_33_SPN520ErrValDiagc "SWTST_u8DiagcERC1_RX_SA_33_SPN520ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121B8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcERC1_RX_SA_33_SPN571ErrValDiagc "SWTST_u8DiagcERC1_RX_SA_33_SPN571ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121B7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcERC1_RX_SA_41_SPN1716ErrValDiagc "SWTST_u8DiagcERC1_RX_SA_41_SPN1716ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121B6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcERC1_RX_SA_41_SPN520ErrValDiagc "SWTST_u8DiagcERC1_RX_SA_41_SPN520ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121B5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcERC1_RX_SA_41_SPN571ErrValDiagc "SWTST_u8DiagcERC1_RX_SA_41_SPN571ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121B4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcERC1_RX_SA_49_SPN1716ErrValDiagc "SWTST_u8DiagcERC1_RX_SA_49_SPN1716ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121B3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcERC1_RX_SA_49_SPN520ErrValDiagc "SWTST_u8DiagcERC1_RX_SA_49_SPN520ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121B2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcERC1_RX_SA_49_SPN571ErrValDiagc "SWTST_u8DiagcERC1_RX_SA_49_SPN571ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121B1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcET1_RX_SA_00ErrValDiagc "SWTST_u8DiagcET1_RX_SA_00ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121AF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcET1_RX_SA_00_SPN110ErrValDiagc "SWTST_u8DiagcET1_RX_SA_00_SPN110ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121B0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcEepromFlt "SWTST_u8DiagcEepromFlt" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121CA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcFspSt "SWTST_u8DiagcFspSt" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121AE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcMsgIdx "SWTST_u8DiagcMsgIdx" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010DF2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcPEDAL_SIGNAL29 "SWTST_u8DiagcPEDAL_SIGNAL29" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121AD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcPEDAL_SIGNAL91 "SWTST_u8DiagcPEDAL_SIGNAL91" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcPTODE_RX_SA_23ErrValDiagc "SWTST_u8DiagcPTODE_RX_SA_23ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121A9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcPTODE_RX_SA_23_SPN3454ErrValDiagc "SWTST_u8DiagcPTODE_RX_SA_23_SPN3454ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121AA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcPTODE_RX_SA_33_SPN3454ErrValDiagc "SWTST_u8DiagcPTODE_RX_SA_33_SPN3454ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121A8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcPTODE_RX_SA_49_SPN3454ErrValDiagc "SWTST_u8DiagcPTODE_RX_SA_49_SPN3454ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121A7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcPTO_SWITCH "SWTST_u8DiagcPTO_SWITCH" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121AB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcPwmIptFltTst "SWTST_u8DiagcPwmIptFltTst" UBYTE I_5 1 2 0 255 MATRIX_DIM 2 3 1 ECU_ADDRESS 0x600121A1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcPwmIptFltTst[0][0] "SWTST_u8DiagcPwmIptFltTst[0][0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121A1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcPwmIptFltTst[0][1] "SWTST_u8DiagcPwmIptFltTst[0][1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121A2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcPwmIptFltTst[1][0] "SWTST_u8DiagcPwmIptFltTst[1][0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121A3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcPwmIptFltTst[1][1] "SWTST_u8DiagcPwmIptFltTst[1][1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121A4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcPwmIptFltTst[2][0] "SWTST_u8DiagcPwmIptFltTst[2][0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121A5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcPwmIptFltTst[2][1] "SWTST_u8DiagcPwmIptFltTst[2][1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121A6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcRETARDER_COMMAND1716 "SWTST_u8DiagcRETARDER_COMMAND1716" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001219D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcRETARDER_COMMAND520 "SWTST_u8DiagcRETARDER_COMMAND520" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001219C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcRETARDER_COMMAND571 "SWTST_u8DiagcRETARDER_COMMAND571" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001219B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcRamTstFlt "SWTST_u8DiagcRamTstFlt" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600121A0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcResetCircuitFlt "SWTST_u8DiagcResetCircuitFlt" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001219F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcResumeTstNr "SWTST_u8DiagcResumeTstNr" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001219E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSpdFltTst "SWTST_u8DiagcSpdFltTst" UBYTE I_5 1 2 0 255 MATRIX_DIM 6 2 1 ECU_ADDRESS 0x6001218F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSpdFltTst[0][0] "SWTST_u8DiagcSpdFltTst[0][0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001218F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSpdFltTst[0][1] "SWTST_u8DiagcSpdFltTst[0][1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012190 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSpdFltTst[0][2] "SWTST_u8DiagcSpdFltTst[0][2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012191 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSpdFltTst[0][3] "SWTST_u8DiagcSpdFltTst[0][3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012192 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSpdFltTst[0][4] "SWTST_u8DiagcSpdFltTst[0][4]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012193 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSpdFltTst[0][5] "SWTST_u8DiagcSpdFltTst[0][5]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012194 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSpdFltTst[1][0] "SWTST_u8DiagcSpdFltTst[1][0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012195 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSpdFltTst[1][1] "SWTST_u8DiagcSpdFltTst[1][1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012196 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSpdFltTst[1][2] "SWTST_u8DiagcSpdFltTst[1][2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012197 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSpdFltTst[1][3] "SWTST_u8DiagcSpdFltTst[1][3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012198 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSpdFltTst[1][4] "SWTST_u8DiagcSpdFltTst[1][4]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012199 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSpdFltTst[1][5] "SWTST_u8DiagcSpdFltTst[1][5]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001219A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSpdoScFlt "SWTST_u8DiagcSpdoScFlt" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001218E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSpdoScsFlt "SWTST_u8DiagcSpdoScsFlt" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001218D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSplyFltTst "SWTST_u8DiagcSplyFltTst" UBYTE I_5 1 2 0 255 MATRIX_DIM 5 4 1 ECU_ADDRESS 0x60012179 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSplyFltTst[0][0] "SWTST_u8DiagcSplyFltTst[0][0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012179 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSplyFltTst[0][1] "SWTST_u8DiagcSplyFltTst[0][1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001217A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSplyFltTst[0][2] "SWTST_u8DiagcSplyFltTst[0][2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001217B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSplyFltTst[0][3] "SWTST_u8DiagcSplyFltTst[0][3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001217C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSplyFltTst[0][4] "SWTST_u8DiagcSplyFltTst[0][4]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001217D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSplyFltTst[1][0] "SWTST_u8DiagcSplyFltTst[1][0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001217E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSplyFltTst[1][1] "SWTST_u8DiagcSplyFltTst[1][1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001217F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSplyFltTst[1][2] "SWTST_u8DiagcSplyFltTst[1][2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012180 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSplyFltTst[1][3] "SWTST_u8DiagcSplyFltTst[1][3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012181 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSplyFltTst[1][4] "SWTST_u8DiagcSplyFltTst[1][4]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012182 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSplyFltTst[2][0] "SWTST_u8DiagcSplyFltTst[2][0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012183 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSplyFltTst[2][1] "SWTST_u8DiagcSplyFltTst[2][1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012184 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSplyFltTst[2][2] "SWTST_u8DiagcSplyFltTst[2][2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012185 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSplyFltTst[2][3] "SWTST_u8DiagcSplyFltTst[2][3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012186 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSplyFltTst[2][4] "SWTST_u8DiagcSplyFltTst[2][4]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012187 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSplyFltTst[3][0] "SWTST_u8DiagcSplyFltTst[3][0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012188 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSplyFltTst[3][1] "SWTST_u8DiagcSplyFltTst[3][1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012189 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSplyFltTst[3][2] "SWTST_u8DiagcSplyFltTst[3][2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001218A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSplyFltTst[3][3] "SWTST_u8DiagcSplyFltTst[3][3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001218B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSplyFltTst[3][4] "SWTST_u8DiagcSplyFltTst[3][4]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001218C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSplyHiFlt "SWTST_u8DiagcSplyHiFlt" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012178 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcSplyLoFlt "SWTST_u8DiagcSplyLoFlt" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012177 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcTC1_RX_SA_05ErrValDiagc "SWTST_u8DiagcTC1_RX_SA_05ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012174 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcTC1_RX_SA_05_Global_DA_SPN525ErrValDiagc "SWTST_u8DiagcTC1_RX_SA_05_Global_DA_SPN525ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012176 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcTC1_RX_SA_05_SPN525ErrValDiagc "SWTST_u8DiagcTC1_RX_SA_05_SPN525ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012175 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcTC1_RX_SA_06_Global_DA_SPN525ErrValDiagc "SWTST_u8DiagcTC1_RX_SA_06_Global_DA_SPN525ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012173 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcTC1_RX_SA_06_SPN525ErrValDiagc "SWTST_u8DiagcTC1_RX_SA_06_SPN525ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012172 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcTC1_RX_SA_23_Global_DA_SPN525ErrValDiagc "SWTST_u8DiagcTC1_RX_SA_23_Global_DA_SPN525ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012171 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcTC1_RX_SA_23_SPN525ErrValDiagc "SWTST_u8DiagcTC1_RX_SA_23_SPN525ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012170 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcTC1_RX_SA_33_Global_DA_SPN525ErrValDiagc "SWTST_u8DiagcTC1_RX_SA_33_Global_DA_SPN525ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001216F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcTC1_RX_SA_33_SPN525ErrValDiagc "SWTST_u8DiagcTC1_RX_SA_33_SPN525ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001216E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcTC1_RX_SA_42_Global_DA_SPN525ErrValDiagc "SWTST_u8DiagcTC1_RX_SA_42_Global_DA_SPN525ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001216D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcTC1_RX_SA_42_SPN525ErrValDiagc "SWTST_u8DiagcTC1_RX_SA_42_SPN525ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001216C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcTC1_RX_SA_49_Global_DA_SPN525ErrValDiagc "SWTST_u8DiagcTC1_RX_SA_49_Global_DA_SPN525ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001216B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcTC1_RX_SA_49_SPN525ErrValDiagc "SWTST_u8DiagcTC1_RX_SA_49_SPN525ErrValDiagc" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001216A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcTstDoneNr "Last test done" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012169 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcTstErrId "Identifier of the first error in the test sequence" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012168 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcTstNrNm1 "'Previous value of ''SWTST_ku8DiagcTstNrC'''" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012167 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DiagcVEHICLE_SPEED "SWTST_u8DiagcVEHICLE_SPEED" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012166 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DioResumeTstNr "SWTST_u8DioResumeTstNr" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012165 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DioTstDoneNr "SWTST_u8DioTstDoneNr" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012164 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DioTstErrId "SWTST_u8DioTstErrId" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012163 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8DioTstNrNm1 "SWTST_u8DioTstNrNm1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012162 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8FimResumeTstNr "SWTST_u8FimResumeTstNr" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012161 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8FimTstDoneNr "Last test done" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012160 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8FimTstErrId "Identifier of the first error in the test sequence" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001215F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8FimTstNrNm1 "'Previous value of ''SWTST_ku8FimTstNrC'''" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001215E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Lvl2RamCrcTstNr "SWTST_u8Lvl2RamCrcTstNr" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001215D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8SftyResumeTstNr "SWTST_u8SftyResumeTstNr" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001215C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8SftyRstCntr "Safety Reset counter" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001215B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8SftyTstDoneNr "Last test done" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001215A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8SftyTstErrId "Identifier of the first error in the test sequence" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012159 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8SftyTstNrNm1 "'Previous value of ''SWTST_ku8SftyTstNrC'''" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012158 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle62X0ResumeTstNr "SWTST_u8Tle62X0ResumeTstNr" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012157 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle62X0TstDoneNr "Last test done" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012156 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle62X0TstErrId "Identifier of the first error in the test sequence" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012155 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle62X0TstNrNm1 "'Previous value of ''SWTST_ku8Tle62X0TstNrC'''" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012154 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle8242ReadOpenLoopLnrVlv1_1 "SWTST_u8Tle8242ReadOpenLoopLnrVlv1_1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012153 /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle8242ReadOpenLoopLnrVlv1_2 "SWTST_u8Tle8242ReadOpenLoopLnrVlv1_2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012152 /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle8242ReadOpenLoopLnrVlv2_3 "SWTST_u8Tle8242ReadOpenLoopLnrVlv2_3" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012151 /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle8242ReadOpenLoopLnrVlv2_4 "SWTST_u8Tle8242ReadOpenLoopLnrVlv2_4" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012150 /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle8242ReadOpenLoopLnrVlv2_5 "SWTST_u8Tle8242ReadOpenLoopLnrVlv2_5" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001214F /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle8242ReadOpenLoopLnrVlv3_6 "SWTST_u8Tle8242ReadOpenLoopLnrVlv3_6" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001214E /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle8242ReadOpenLoopLnrVlv3_7 "SWTST_u8Tle8242ReadOpenLoopLnrVlv3_7" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001214D /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle8242ReadOpenLoopLnrVlv3_8 "SWTST_u8Tle8242ReadOpenLoopLnrVlv3_8" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001214C /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle8242ReadOpenLoopLnrVlv4_10 "SWTST_u8Tle8242ReadOpenLoopLnrVlv4_10" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001214B /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle8242ReadOpenLoopLnrVlv4_9 "SWTST_u8Tle8242ReadOpenLoopLnrVlv4_9" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001214A /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle8242ReadOpenLoopPwmVlv1_1 "SWTST_u8Tle8242ReadOpenLoopPwmVlv1_1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012149 /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle8242ReadOpenLoopPwmVlv1_2 "SWTST_u8Tle8242ReadOpenLoopPwmVlv1_2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012148 /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle8242ReadOpenLoopPwmVlv1_3 "SWTST_u8Tle8242ReadOpenLoopPwmVlv1_3" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012147 /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle8242ReadOpenLoopPwmVlv4_4 "SWTST_u8Tle8242ReadOpenLoopPwmVlv4_4" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012146 /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle8242ReadOpenLoopPwmVlv4_5 "SWTST_u8Tle8242ReadOpenLoopPwmVlv4_5" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012145 /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle8242ResumeTstNr "SWTST_u8Tle8242ResumeTstNr" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012144 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle8242TstDoneNr "Last test done" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012143 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle8242TstErrId "Identifier of the first error in the test sequence" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012142 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle8242TstNrNm1 "'Previous value of ''SWTST_ku8Tle8242TstNrC'''" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012141 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle8242WrOpenLoopLnrVlv1_1 "SWTST_u8Tle8242WrOpenLoopLnrVlv1_1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012140 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle8242WrOpenLoopLnrVlv1_2 "SWTST_u8Tle8242WrOpenLoopLnrVlv1_2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001213F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle8242WrOpenLoopLnrVlv2_3 "SWTST_u8Tle8242WrOpenLoopLnrVlv2_3" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001213E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle8242WrOpenLoopLnrVlv2_4 "SWTST_u8Tle8242WrOpenLoopLnrVlv2_4" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001213D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle8242WrOpenLoopLnrVlv2_5 "SWTST_u8Tle8242WrOpenLoopLnrVlv2_5" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001213C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle8242WrOpenLoopLnrVlv3_6 "SWTST_u8Tle8242WrOpenLoopLnrVlv3_6" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001213B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle8242WrOpenLoopLnrVlv3_7 "SWTST_u8Tle8242WrOpenLoopLnrVlv3_7" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001213A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle8242WrOpenLoopLnrVlv3_8 "SWTST_u8Tle8242WrOpenLoopLnrVlv3_8" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012139 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle8242WrOpenLoopLnrVlv4_9 "SWTST_u8Tle8242WrOpenLoopLnrVlv4_9" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012137 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle8242WrOpenLoopPwmVlv1_1 "SWTST_u8Tle8242WrOpenLoopPwmVlv1_1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012136 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle8242WrOpenLoopPwmVlv1_2 "SWTST_u8Tle8242WrOpenLoopPwmVlv1_2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012135 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle8242WrOpenLoopPwmVlv1_3 "SWTST_u8Tle8242WrOpenLoopPwmVlv1_3" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012134 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle8242WrOpenLoopPwmVlv4_4 "SWTST_u8Tle8242WrOpenLoopPwmVlv4_4" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012133 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Tle8242WrOpenLoopPwmVlv4_5 "SWTST_u8Tle8242WrOpenLoopPwmVlv4_5" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012132 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8TrimResumeTstNr "SWTST_u8TrimResumeTstNr" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012131 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8TrimTstDoneNr "Last test done" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012130 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8TrimTstErrId "Identifier of the first error in the test sequence" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001212F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8TrimTstNrNm1 "'Previous value of ''SWTST_ku8TrimTstNrC'''" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001212E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8WdgResumeTstNr "SWTST_u8WdgResumeTstNr" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001212D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8WdgTstDoneNr "Last test done" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001212C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8WdgTstErrId "Identifier of the first error in the test sequence" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001212B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8WdgTstNrNm1 "'Previous value of ''SWTST_ku8WdgTstNrC'''" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001212A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRd0200 "SWTST_udtDcmCallBackDidFor2fRd0200" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A50 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRd0201 "SWTST_udtDcmCallBackDidFor2fRd0201" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A4C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRd0202 "SWTST_udtDcmCallBackDidFor2fRd0202" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A48 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRd0203 "SWTST_udtDcmCallBackDidFor2fRd0203" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A44 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRd0204 "SWTST_udtDcmCallBackDidFor2fRd0204" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A40 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRd0205 "SWTST_udtDcmCallBackDidFor2fRd0205" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A3C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRd0206 "SWTST_udtDcmCallBackDidFor2fRd0206" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A38 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRd0207 "SWTST_udtDcmCallBackDidFor2fRd0207" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A34 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRd0208 "SWTST_udtDcmCallBackDidFor2fRd0208" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A30 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRd0209 "SWTST_udtDcmCallBackDidFor2fRd0209" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A2C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRdErrCode0200 "SWTST_udtDcmCallBackDidFor2fRdErrCode0200" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012129 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRdErrCode0201 "SWTST_udtDcmCallBackDidFor2fRdErrCode0201" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012128 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRdErrCode0202 "SWTST_udtDcmCallBackDidFor2fRdErrCode0202" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012127 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRdErrCode0203 "SWTST_udtDcmCallBackDidFor2fRdErrCode0203" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012126 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRdErrCode0204 "SWTST_udtDcmCallBackDidFor2fRdErrCode0204" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012125 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRdErrCode0205 "SWTST_udtDcmCallBackDidFor2fRdErrCode0205" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012124 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRdErrCode0206 "SWTST_udtDcmCallBackDidFor2fRdErrCode0206" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012123 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRdErrCode0207 "SWTST_udtDcmCallBackDidFor2fRdErrCode0207" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012122 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRdErrCode0208 "SWTST_udtDcmCallBackDidFor2fRdErrCode0208" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012121 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRdErrCode0209 "SWTST_udtDcmCallBackDidFor2fRdErrCode0209" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012120 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRetContrl0200 "SWTST_udtDcmCallBackDidFor2fRetContrl0200" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001211F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRetContrl0201 "SWTST_udtDcmCallBackDidFor2fRetContrl0201" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001211E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRetContrl0202 "SWTST_udtDcmCallBackDidFor2fRetContrl0202" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001211D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRetContrl0203 "SWTST_udtDcmCallBackDidFor2fRetContrl0203" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001211C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRetContrl0204 "SWTST_udtDcmCallBackDidFor2fRetContrl0204" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001211B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRetContrl0205 "SWTST_udtDcmCallBackDidFor2fRetContrl0205" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001211A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRetContrl0206 "SWTST_udtDcmCallBackDidFor2fRetContrl0206" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012119 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRetContrl0207 "SWTST_udtDcmCallBackDidFor2fRetContrl0207" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012118 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRetContrl0208 "SWTST_udtDcmCallBackDidFor2fRetContrl0208" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012117 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRetContrl0209 "SWTST_udtDcmCallBackDidFor2fRetContrl0209" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012116 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRetContrlErrCode0200 "SWTST_udtDcmCallBackDidFor2fRetContrlErrCode0200" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012115 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRetContrlErrCode0201 "SWTST_udtDcmCallBackDidFor2fRetContrlErrCode0201" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012114 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRetContrlErrCode0202 "SWTST_udtDcmCallBackDidFor2fRetContrlErrCode0202" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012113 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRetContrlErrCode0203 "SWTST_udtDcmCallBackDidFor2fRetContrlErrCode0203" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012112 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRetContrlErrCode0204 "SWTST_udtDcmCallBackDidFor2fRetContrlErrCode0204" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012111 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRetContrlErrCode0205 "SWTST_udtDcmCallBackDidFor2fRetContrlErrCode0205" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012110 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRetContrlErrCode0206 "SWTST_udtDcmCallBackDidFor2fRetContrlErrCode0206" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001210F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRetContrlErrCode0207 "SWTST_udtDcmCallBackDidFor2fRetContrlErrCode0207" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001210E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRetContrlErrCode0208 "SWTST_udtDcmCallBackDidFor2fRetContrlErrCode0208" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001210D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fRetContrlErrCode0209 "SWTST_udtDcmCallBackDidFor2fRetContrlErrCode0209" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001210C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fShortContrl0200 "SWTST_udtDcmCallBackDidFor2fShortContrl0200" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A28 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fShortContrl0201 "SWTST_udtDcmCallBackDidFor2fShortContrl0201" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A24 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fShortContrl0202 "SWTST_udtDcmCallBackDidFor2fShortContrl0202" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A20 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fShortContrl0203 "SWTST_udtDcmCallBackDidFor2fShortContrl0203" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A1C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fShortContrl0204 "SWTST_udtDcmCallBackDidFor2fShortContrl0204" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A18 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fShortContrl0205 "SWTST_udtDcmCallBackDidFor2fShortContrl0205" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A14 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fShortContrl0206 "SWTST_udtDcmCallBackDidFor2fShortContrl0206" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A10 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fShortContrl0207 "SWTST_udtDcmCallBackDidFor2fShortContrl0207" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A0C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fShortContrl0208 "SWTST_udtDcmCallBackDidFor2fShortContrl0208" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A08 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fShortContrl0209 "SWTST_udtDcmCallBackDidFor2fShortContrl0209" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A04 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fShortContrlErrCode0200 "SWTST_udtDcmCallBackDidFor2fShortContrlErrCode0200" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001210B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fShortContrlErrCode0201 "SWTST_udtDcmCallBackDidFor2fShortContrlErrCode0201" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001210A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fShortContrlErrCode0202 "SWTST_udtDcmCallBackDidFor2fShortContrlErrCode0202" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012109 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fShortContrlErrCode0203 "SWTST_udtDcmCallBackDidFor2fShortContrlErrCode0203" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012108 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fShortContrlErrCode0204 "SWTST_udtDcmCallBackDidFor2fShortContrlErrCode0204" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012107 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fShortContrlErrCode0205 "SWTST_udtDcmCallBackDidFor2fShortContrlErrCode0205" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012106 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fShortContrlErrCode0206 "SWTST_udtDcmCallBackDidFor2fShortContrlErrCode0206" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012105 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fShortContrlErrCode0207 "SWTST_udtDcmCallBackDidFor2fShortContrlErrCode0207" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012104 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fShortContrlErrCode0208 "SWTST_udtDcmCallBackDidFor2fShortContrlErrCode0208" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012103 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor2fShortContrlErrCode0209 "SWTST_udtDcmCallBackDidFor2fShortContrlErrCode0209" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012102 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor31ReqResDF00 "SWTST_udtDcmCallBackDidFor31ReqResDF00" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A00 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor31ReqResDF01 "SWTST_udtDcmCallBackDidFor31ReqResDF01" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600129FC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor31ReqResDF02 "SWTST_udtDcmCallBackDidFor31ReqResDF02" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600129F8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor31ReqResErrCodeDF00 "SWTST_udtDcmCallBackDidFor31ReqResErrCodeDF00" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012101 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor31ReqResErrCodeDF01 "SWTST_udtDcmCallBackDidFor31ReqResErrCodeDF01" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012100 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor31ReqResErrCodeDF02 "SWTST_udtDcmCallBackDidFor31ReqResErrCodeDF02" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120FF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor31StartErrCodeDF00 "SWTST_udtDcmCallBackDidFor31StartErrCodeDF00" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120FE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor31StartErrCodeDF01 "SWTST_udtDcmCallBackDidFor31StartErrCodeDF01" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120FD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor31StartErrCodeDF02 "SWTST_udtDcmCallBackDidFor31StartErrCodeDF02" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120FC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor31StartFlagDF00 "SWTST_udtDcmCallBackDidFor31StartFlagDF00" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120FB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor31StartFlagDF01 "SWTST_udtDcmCallBackDidFor31StartFlagDF01" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120FA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidFor31StartFlagDF02 "SWTST_udtDcmCallBackDidFor31StartFlagDF02" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120F9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0100 "SWTST_udtDcmCallBackDidForRd0100" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600129C8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0101 "SWTST_udtDcmCallBackDidForRd0101" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600129C4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0102 "SWTST_udtDcmCallBackDidForRd0102" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600129C0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0103 "SWTST_udtDcmCallBackDidForRd0103" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600129BC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0104 "SWTST_udtDcmCallBackDidForRd0104" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600129B8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0105 "SWTST_udtDcmCallBackDidForRd0105" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600129B4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0106 "SWTST_udtDcmCallBackDidForRd0106" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600129B0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0107 "SWTST_udtDcmCallBackDidForRd0107" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600129AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0108 "SWTST_udtDcmCallBackDidForRd0108" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600129A8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0109 "SWTST_udtDcmCallBackDidForRd0109" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600129A4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd010A "SWTST_udtDcmCallBackDidForRd010A" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600129A0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd010B "SWTST_udtDcmCallBackDidForRd010B" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001299C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd010C "SWTST_udtDcmCallBackDidForRd010C" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012998 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd010D "SWTST_udtDcmCallBackDidForRd010D" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012994 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd010E "SWTST_udtDcmCallBackDidForRd010E" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012990 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd010F "SWTST_udtDcmCallBackDidForRd010F" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001298C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0110 "SWTST_udtDcmCallBackDidForRd0110" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012988 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0111 "SWTST_udtDcmCallBackDidForRd0111" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012984 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0112 "SWTST_udtDcmCallBackDidForRd0112" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012980 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0113 "SWTST_udtDcmCallBackDidForRd0113" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001297C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0114 "SWTST_udtDcmCallBackDidForRd0114" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120EE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0115 "SWTST_udtDcmCallBackDidForRd0115" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120ED READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0116 "SWTST_udtDcmCallBackDidForRd0116" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120EC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0130 "SWTST_udtDcmCallBackDidForRd0130" UBYTE I_5 1 2 0 255 MATRIX_DIM 17 1 1 ECU_ADDRESS 0x600120DB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0130[0] "SWTST_udtDcmCallBackDidForRd0130[0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120DB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0130[10] "SWTST_udtDcmCallBackDidForRd0130[10]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120E5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0130[11] "SWTST_udtDcmCallBackDidForRd0130[11]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120E6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0130[12] "SWTST_udtDcmCallBackDidForRd0130[12]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120E7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0130[13] "SWTST_udtDcmCallBackDidForRd0130[13]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120E8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0130[14] "SWTST_udtDcmCallBackDidForRd0130[14]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120E9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0130[15] "SWTST_udtDcmCallBackDidForRd0130[15]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120EA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0130[16] "SWTST_udtDcmCallBackDidForRd0130[16]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120EB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0130[1] "SWTST_udtDcmCallBackDidForRd0130[1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120DC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0130[2] "SWTST_udtDcmCallBackDidForRd0130[2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120DD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0130[3] "SWTST_udtDcmCallBackDidForRd0130[3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120DE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0130[4] "SWTST_udtDcmCallBackDidForRd0130[4]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120DF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0130[5] "SWTST_udtDcmCallBackDidForRd0130[5]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120E0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0130[6] "SWTST_udtDcmCallBackDidForRd0130[6]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120E1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0130[7] "SWTST_udtDcmCallBackDidForRd0130[7]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120E2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0130[8] "SWTST_udtDcmCallBackDidForRd0130[8]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120E3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0130[9] "SWTST_udtDcmCallBackDidForRd0130[9]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120E4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300 "SWTST_udtDcmCallBackDidForRd0300" UBYTE I_5 1 2 0 255 MATRIX_DIM 160 1 1 ECU_ADDRESS 0x6001203B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[0] "SWTST_udtDcmCallBackDidForRd0300[0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001203B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[100] "SWTST_udtDcmCallBackDidForRd0300[100]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001209F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[101] "SWTST_udtDcmCallBackDidForRd0300[101]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120A0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[102] "SWTST_udtDcmCallBackDidForRd0300[102]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120A1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[103] "SWTST_udtDcmCallBackDidForRd0300[103]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120A2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[104] "SWTST_udtDcmCallBackDidForRd0300[104]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120A3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[105] "SWTST_udtDcmCallBackDidForRd0300[105]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120A4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[106] "SWTST_udtDcmCallBackDidForRd0300[106]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120A5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[107] "SWTST_udtDcmCallBackDidForRd0300[107]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120A6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[108] "SWTST_udtDcmCallBackDidForRd0300[108]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120A7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[109] "SWTST_udtDcmCallBackDidForRd0300[109]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120A8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[10] "SWTST_udtDcmCallBackDidForRd0300[10]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012045 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[110] "SWTST_udtDcmCallBackDidForRd0300[110]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120A9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[111] "SWTST_udtDcmCallBackDidForRd0300[111]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120AA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[112] "SWTST_udtDcmCallBackDidForRd0300[112]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120AB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[113] "SWTST_udtDcmCallBackDidForRd0300[113]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[114] "SWTST_udtDcmCallBackDidForRd0300[114]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120AD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[115] "SWTST_udtDcmCallBackDidForRd0300[115]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120AE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[116] "SWTST_udtDcmCallBackDidForRd0300[116]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120AF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[117] "SWTST_udtDcmCallBackDidForRd0300[117]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120B0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[118] "SWTST_udtDcmCallBackDidForRd0300[118]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120B1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[119] "SWTST_udtDcmCallBackDidForRd0300[119]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120B2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[11] "SWTST_udtDcmCallBackDidForRd0300[11]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012046 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[120] "SWTST_udtDcmCallBackDidForRd0300[120]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120B3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[121] "SWTST_udtDcmCallBackDidForRd0300[121]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120B4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[122] "SWTST_udtDcmCallBackDidForRd0300[122]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120B5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[123] "SWTST_udtDcmCallBackDidForRd0300[123]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120B6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[124] "SWTST_udtDcmCallBackDidForRd0300[124]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120B7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[125] "SWTST_udtDcmCallBackDidForRd0300[125]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120B8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[126] "SWTST_udtDcmCallBackDidForRd0300[126]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120B9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[127] "SWTST_udtDcmCallBackDidForRd0300[127]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120BA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[128] "SWTST_udtDcmCallBackDidForRd0300[128]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120BB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[129] "SWTST_udtDcmCallBackDidForRd0300[129]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120BC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[12] "SWTST_udtDcmCallBackDidForRd0300[12]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012047 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[130] "SWTST_udtDcmCallBackDidForRd0300[130]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120BD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[131] "SWTST_udtDcmCallBackDidForRd0300[131]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120BE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[132] "SWTST_udtDcmCallBackDidForRd0300[132]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120BF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[133] "SWTST_udtDcmCallBackDidForRd0300[133]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120C0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[134] "SWTST_udtDcmCallBackDidForRd0300[134]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120C1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[135] "SWTST_udtDcmCallBackDidForRd0300[135]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120C2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[136] "SWTST_udtDcmCallBackDidForRd0300[136]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120C3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[137] "SWTST_udtDcmCallBackDidForRd0300[137]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120C4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[138] "SWTST_udtDcmCallBackDidForRd0300[138]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120C5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[139] "SWTST_udtDcmCallBackDidForRd0300[139]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120C6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[13] "SWTST_udtDcmCallBackDidForRd0300[13]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012048 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[140] "SWTST_udtDcmCallBackDidForRd0300[140]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120C7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[141] "SWTST_udtDcmCallBackDidForRd0300[141]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120C8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[142] "SWTST_udtDcmCallBackDidForRd0300[142]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120C9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[143] "SWTST_udtDcmCallBackDidForRd0300[143]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120CA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[144] "SWTST_udtDcmCallBackDidForRd0300[144]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120CB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[145] "SWTST_udtDcmCallBackDidForRd0300[145]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120CC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[146] "SWTST_udtDcmCallBackDidForRd0300[146]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120CD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[147] "SWTST_udtDcmCallBackDidForRd0300[147]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120CE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[148] "SWTST_udtDcmCallBackDidForRd0300[148]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120CF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[149] "SWTST_udtDcmCallBackDidForRd0300[149]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120D0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[14] "SWTST_udtDcmCallBackDidForRd0300[14]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012049 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[150] "SWTST_udtDcmCallBackDidForRd0300[150]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120D1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[151] "SWTST_udtDcmCallBackDidForRd0300[151]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120D2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[152] "SWTST_udtDcmCallBackDidForRd0300[152]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120D3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[153] "SWTST_udtDcmCallBackDidForRd0300[153]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120D4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[154] "SWTST_udtDcmCallBackDidForRd0300[154]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120D5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[155] "SWTST_udtDcmCallBackDidForRd0300[155]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120D6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[156] "SWTST_udtDcmCallBackDidForRd0300[156]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120D7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[157] "SWTST_udtDcmCallBackDidForRd0300[157]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120D8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[158] "SWTST_udtDcmCallBackDidForRd0300[158]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120D9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[159] "SWTST_udtDcmCallBackDidForRd0300[159]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120DA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[15] "SWTST_udtDcmCallBackDidForRd0300[15]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001204A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[16] "SWTST_udtDcmCallBackDidForRd0300[16]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001204B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[17] "SWTST_udtDcmCallBackDidForRd0300[17]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001204C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[18] "SWTST_udtDcmCallBackDidForRd0300[18]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001204D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[19] "SWTST_udtDcmCallBackDidForRd0300[19]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001204E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[1] "SWTST_udtDcmCallBackDidForRd0300[1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001203C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[20] "SWTST_udtDcmCallBackDidForRd0300[20]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001204F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[21] "SWTST_udtDcmCallBackDidForRd0300[21]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012050 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[22] "SWTST_udtDcmCallBackDidForRd0300[22]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012051 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[23] "SWTST_udtDcmCallBackDidForRd0300[23]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012052 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[24] "SWTST_udtDcmCallBackDidForRd0300[24]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012053 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[25] "SWTST_udtDcmCallBackDidForRd0300[25]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012054 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[26] "SWTST_udtDcmCallBackDidForRd0300[26]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012055 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[27] "SWTST_udtDcmCallBackDidForRd0300[27]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012056 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[28] "SWTST_udtDcmCallBackDidForRd0300[28]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012057 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[29] "SWTST_udtDcmCallBackDidForRd0300[29]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012058 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[2] "SWTST_udtDcmCallBackDidForRd0300[2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001203D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[30] "SWTST_udtDcmCallBackDidForRd0300[30]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012059 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[31] "SWTST_udtDcmCallBackDidForRd0300[31]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001205A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[32] "SWTST_udtDcmCallBackDidForRd0300[32]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001205B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[33] "SWTST_udtDcmCallBackDidForRd0300[33]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001205C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[34] "SWTST_udtDcmCallBackDidForRd0300[34]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001205D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[35] "SWTST_udtDcmCallBackDidForRd0300[35]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001205E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[36] "SWTST_udtDcmCallBackDidForRd0300[36]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001205F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[37] "SWTST_udtDcmCallBackDidForRd0300[37]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012060 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[38] "SWTST_udtDcmCallBackDidForRd0300[38]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012061 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[39] "SWTST_udtDcmCallBackDidForRd0300[39]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012062 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[3] "SWTST_udtDcmCallBackDidForRd0300[3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001203E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[40] "SWTST_udtDcmCallBackDidForRd0300[40]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012063 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[41] "SWTST_udtDcmCallBackDidForRd0300[41]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012064 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[42] "SWTST_udtDcmCallBackDidForRd0300[42]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012065 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[43] "SWTST_udtDcmCallBackDidForRd0300[43]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012066 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[44] "SWTST_udtDcmCallBackDidForRd0300[44]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012067 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[45] "SWTST_udtDcmCallBackDidForRd0300[45]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012068 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[46] "SWTST_udtDcmCallBackDidForRd0300[46]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012069 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[47] "SWTST_udtDcmCallBackDidForRd0300[47]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001206A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[48] "SWTST_udtDcmCallBackDidForRd0300[48]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001206B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[49] "SWTST_udtDcmCallBackDidForRd0300[49]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001206C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[4] "SWTST_udtDcmCallBackDidForRd0300[4]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001203F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[50] "SWTST_udtDcmCallBackDidForRd0300[50]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001206D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[51] "SWTST_udtDcmCallBackDidForRd0300[51]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001206E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[52] "SWTST_udtDcmCallBackDidForRd0300[52]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001206F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[53] "SWTST_udtDcmCallBackDidForRd0300[53]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012070 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[54] "SWTST_udtDcmCallBackDidForRd0300[54]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012071 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[55] "SWTST_udtDcmCallBackDidForRd0300[55]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012072 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[56] "SWTST_udtDcmCallBackDidForRd0300[56]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012073 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[57] "SWTST_udtDcmCallBackDidForRd0300[57]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012074 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[58] "SWTST_udtDcmCallBackDidForRd0300[58]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012075 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[59] "SWTST_udtDcmCallBackDidForRd0300[59]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012076 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[5] "SWTST_udtDcmCallBackDidForRd0300[5]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012040 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[60] "SWTST_udtDcmCallBackDidForRd0300[60]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012077 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[61] "SWTST_udtDcmCallBackDidForRd0300[61]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012078 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[62] "SWTST_udtDcmCallBackDidForRd0300[62]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012079 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[63] "SWTST_udtDcmCallBackDidForRd0300[63]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001207A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[64] "SWTST_udtDcmCallBackDidForRd0300[64]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001207B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[65] "SWTST_udtDcmCallBackDidForRd0300[65]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001207C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[66] "SWTST_udtDcmCallBackDidForRd0300[66]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001207D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[67] "SWTST_udtDcmCallBackDidForRd0300[67]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001207E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[68] "SWTST_udtDcmCallBackDidForRd0300[68]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001207F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[69] "SWTST_udtDcmCallBackDidForRd0300[69]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012080 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[6] "SWTST_udtDcmCallBackDidForRd0300[6]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012041 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[70] "SWTST_udtDcmCallBackDidForRd0300[70]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012081 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[71] "SWTST_udtDcmCallBackDidForRd0300[71]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012082 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[72] "SWTST_udtDcmCallBackDidForRd0300[72]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012083 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[73] "SWTST_udtDcmCallBackDidForRd0300[73]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012084 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[74] "SWTST_udtDcmCallBackDidForRd0300[74]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012085 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[75] "SWTST_udtDcmCallBackDidForRd0300[75]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012086 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[76] "SWTST_udtDcmCallBackDidForRd0300[76]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012087 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[77] "SWTST_udtDcmCallBackDidForRd0300[77]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012088 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[78] "SWTST_udtDcmCallBackDidForRd0300[78]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012089 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[79] "SWTST_udtDcmCallBackDidForRd0300[79]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001208A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[7] "SWTST_udtDcmCallBackDidForRd0300[7]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012042 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[80] "SWTST_udtDcmCallBackDidForRd0300[80]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001208B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[81] "SWTST_udtDcmCallBackDidForRd0300[81]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001208C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[82] "SWTST_udtDcmCallBackDidForRd0300[82]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001208D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[83] "SWTST_udtDcmCallBackDidForRd0300[83]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001208E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[84] "SWTST_udtDcmCallBackDidForRd0300[84]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001208F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[85] "SWTST_udtDcmCallBackDidForRd0300[85]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012090 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForRd0300[86] "SWTST_udtDcmCallBackDidForRd0300[86]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012091 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForffRdFF02 "SWTST_udtDcmCallBackDidForffRdFF02" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010DF0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForffRdFF04 "SWTST_udtDcmCallBackDidForffRdFF04" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120F8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForffRdFF05 "SWTST_udtDcmCallBackDidForffRdFF05" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120F7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForffRdFF0C "SWTST_udtDcmCallBackDidForffRdFF0C" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010DEE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForffRdFF0D "SWTST_udtDcmCallBackDidForffRdFF0D" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010DEC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForffRdFF42 "SWTST_udtDcmCallBackDidForffRdFF42" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600129F4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForffRdFF49 "SWTST_udtDcmCallBackDidForffRdFF49" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600129F0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForffRdFF61 "SWTST_udtDcmCallBackDidForffRdFF61" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120F6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForffRdFF62 "SWTST_udtDcmCallBackDidForffRdFF62" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120F5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForffRdFF63 "SWTST_udtDcmCallBackDidForffRdFF63" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120F4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForffRdFF64 "SWTST_udtDcmCallBackDidForffRdFF64" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120F3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForffRdFF65 "SWTST_udtDcmCallBackDidForffRdFF65" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120F2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForffRdFF66 "SWTST_udtDcmCallBackDidForffRdFF66" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120F1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForffRdFF67 "SWTST_udtDcmCallBackDidForffRdFF67" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600129EC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForffRdFF68 "SWTST_udtDcmCallBackDidForffRdFF68" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600129E8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForffRdFF69 "SWTST_udtDcmCallBackDidForffRdFF69" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600129E4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForffRdFF6A "SWTST_udtDcmCallBackDidForffRdFF6A" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120F0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForffRdFF6B "SWTST_udtDcmCallBackDidForffRdFF6B" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600129E0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForffRdFF6C "SWTST_udtDcmCallBackDidForffRdFF6C" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600129DC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForffRdFF6D "SWTST_udtDcmCallBackDidForffRdFF6D" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600129D8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForffRdFF6E "SWTST_udtDcmCallBackDidForffRdFF6E" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600129D4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForffRdFF6F "SWTST_udtDcmCallBackDidForffRdFF6F" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600129D0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForffRdFF71 "SWTST_udtDcmCallBackDidForffRdFF71" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600129CC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidForffRdFF72 "SWTST_udtDcmCallBackDidForffRdFF72" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600120EF READ_WRITE /end MEASUREMENT
/begin COMPU_METHOD I_5 "" RAT_FUNC "%9.2" "-" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin FUNCTION SWTST "" FUNCTION_VERSION "NONE_"
 /begin OUT_MEASUREMENT SWTST_u8ComRdPtodeSa49EnggmntCnsntPTOEngAccssoryDrive1 SWTST_u8ComRdPtodeSa49EnggmntCnsntPTOEngAccssoryDrive2 SWTST_u8ComRdPtodeSa49EnggmntCnsntTrnsfrCsOtptShaftPTO SWTST_u8ComRdPtodeSa49EnggmntStatusTransInputShaftPTO1 SWTST_u8ComRdPtodeSa49EnggmntStatusTransInputShaftPTO2 SWTST_u8ComRdPtodeSa49EnggmntStatusTransOutputShaftPTO SWTST_u8ComRdPtodeSa49EnggmntSttsPTOEngAccessoryDrive1 SWTST_u8ComRdPtodeSa49EnggmntSttsPTOEngAccessoryDrive2 SWTST_u8ComRdPtodeSa49EnggmntSttsTrnsfrCsOtputShaftPTO SWTST_u8ComRdRcSa15RetarderCtrlMethod SWTST_u8ComRdRcSa15RetarderLocation SWTST_u8ComRdRcSa15RetarderType SWTST_u8ComRdRcSa41RetarderCtrlMethod SWTST_u8ComRdRcSa41RetarderLocation SWTST_u8ComRdRcSa41RetarderType SWTST_u8ComRdRxBMSFailSa243RxBatErr SWTST_u8ComRdRxBMSFailSa243RxBatPlugState SWTST_u8ComRdRxBMSFailSa243RxBMSLifeSignal SWTST_u8ComRdRxBMSMainParaSa243RxBatErrRank SWTST_u8ComRdRxBMSMainParaSa243RxBatHeatRelayState SWTST_u8ComRdRxBMSMainParaSa243RxBatTotalNegRelayState SWTST_u8ComRdRxBMSMainParaSa243RxBatTotalPosRelayState SWTST_u8ComRdRxBMSMainParaSa243RxBMSRequst SWTST_u8ComRdRxBMSMainParaSa243RxBMSState SWTST_u8ComRdRxBrkPumpCtrlSa155Da255RxBrkPumpCtrlBrkPumpSta SWTST_u8ComRdRxBrkPumpCtrlSa155Da255RxBrkPumpCtrlCANSta SWTST_u8ComRdRxBrkPumpCtrlSa155Da255RxBrkPumpCtrlCurrent SWTST_u8ComRdRxBrkPumpCtrlSa155Da255RxBrkPumpCtrlErrCode SWTST_u8ComRdRxBrkPumpCtrlSa155Da255RxBrkPumpCtrlPreCharFed SWTST_u8ComRdRxCLUGearCmdSa05RxCLUCModeSwith SWTST_u8ComRdRxCLUGearCmdSa05RxCLUHandelSta SWTST_u8ComRdRxDBStaVehSa23RxDBAlaBacPres SWTST_u8ComRdRxDBStaVehSa23RxDBAlaFroPres SWTST_u8ComRdRxDBStaVehSa23RxDBBacCabDoor SWTST_u8ComRdRxDBStaVehSa23RxDBMidDoor SWTST_u8ComRdRxDBStaVehSa23RxDBStaFroDoor SWTST_u8ComRdRxDBStaVehSa23RxDBVehON SWTST_u8ComRdRxDBStaVehSa23RxDBVehPKB SWTST_u8ComRdRxDBStaVehSa23RxDBVehStart SWTST_u8ComRdRxDBStaVehSa23RxDBVehStop SWTST_u8ComRdRxDCDCCtrl1Sa243RxDCDCCtrl1CNT SWTST_u8ComRdRxDCDCCtrl1Sa243RxDCDCCtrl1ErrCode SWTST_u8ComRdRxDCDCCtrl1Sa243RxDCDCCtrl1ErrRank SWTST_u8ComRdRxDCDCCtrl1Sa243RxDCDCCtrl1WorkState SWTST_u8ComRdRxHVBoardSa209RxHVBoardEleAtt SWTST_u8ComRdRxHVBoardSa209RxHVBoardEleAttPreCharge SWTST_u8ComRdRxHVBoardSa209RxHVBoardMainMot SWTST_u8ComRdRxHVBoardSa209RxHVBoardMainPreCharge SWTST_u8ComRdRxMCUStatus1Sa08RxMCUActDischaFedback SWTST_u8ComRdRxMCUStatus1Sa08RxMCULiveCounter SWTST_u8ComRdRxMCUStatus1Sa08RxMCUMotSta SWTST_u8ComRdRxMCUStatus1Sa08RxMCUMotWorkMode SWTST_u8ComRdRxMCUStatus1Sa08RxMCUPreChargeAllow SWTST_u8ComRdRxMCUStatus2Sa08RxMCULiveCounter SWTST_u8ComRdRxMCUStatus2Sa08RxMCUMotErrRank SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCCANErr SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCIPMErr SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCOTempInvertWa SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCOTempWindWa SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCOverCurr SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCOverSpd SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCOverTempInvert SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCOverTempWind SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCOverVolt SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCOverVoltWarn SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCResolverErr SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCTempSensorWindErr SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCUnderLowVolt SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCUnderVolt SWTST_u8ComRdRxMCUStatus3Sa08RxMCUDTCUnderVoltWarn SWTST_u8ComRdRxMCUStatus3Sa08RxMCULiveCounter SWTST_u8ComRdRxMCUStatus3Sa08RxMCURotationCount SWTST_u8ComRdRxSteerPumpCtrlSa149Da255RxSteerPumpCtrlCANSta SWTST_u8ComRdRxSteerPumpCtrlSa149Da255RxSteerPumpCtrlCurrent SWTST_u8ComRdRxSteerPumpCtrlSa149Da255RxSteerPumpCtrlErrCode SWTST_u8ComRdRxSteerPumpCtrlSa149Da255RxSteerPumpCtrlNowCtrlledSta SWTST_u8ComRdRxSteerPumpCtrlSa149Da255RxSteerPumpCtrlOilPumpSta SWTST_u8ComRdRxSteerPumpCtrlSa149Da255RxSteerPumpCtrlPreCharFed SWTST_u8ComRdTc1Sa05AutoNeutralReq SWTST_u8ComRdTc1Sa05Da255AutoNeutralReq SWTST_u8ComRdTc1Sa05Da255DisengageDiffLockRqCentral SWTST_u8ComRdTc1Sa05Da255DisengageDiffLockRqCentralFront SWTST_u8ComRdTc1Sa05Da255DisengageDiffLockRqCentralRear SWTST_u8ComRdTc1Sa05Da255DisengageDiffLockRqFrontAxle1 SWTST_u8ComRdTc1Sa05Da255DisengageDiffLockRqFrontAxle2 SWTST_u8ComRdTc1Sa05Da255DisengageDiffLockRqRearAxle1 SWTST_u8ComRdTc1Sa05Da255DisengageDiffLockRqRearAxle2 SWTST_u8ComRdTc1Sa05Da255DisengageDrivelineRq SWTST_u8ComRdTc1Sa05Da255TransGearShiftInhibitRq SWTST_u8ComRdTc1Sa05Da255TransLoadReductionInhibitRq SWTST_u8ComRdTc1Sa05Da255TransMode1 SWTST_u8ComRdTc1Sa05Da255TransMode2 SWTST_u8ComRdTc1Sa05Da255TransMode3 SWTST_u8ComRdTc1Sa05Da255TransMode4 SWTST_u8ComRdTc1Sa05Da255TransMode5 SWTST_u8ComRdTc1Sa05Da255TransMode6 SWTST_u8ComRdTc1Sa05Da255TransMode7 SWTST_u8ComRdTc1Sa05Da255TransMode8 SWTST_u8ComRdTc1Sa05Da255TransRequestedLaunchGear SWTST_u8ComRdTc1Sa05Da255TransReverseGearShiftInhibitRq SWTST_u8ComRdTc1Sa05Da255TrnsShftSlectorDisplayModeSwitch SWTST_u8ComRdTc1Sa05Da255TrnsTrqeConverterLockupDisableRq SWTST_u8ComRdTc1Sa05DisengageDiffLockRqCentral SWTST_u8ComRdTc1Sa05DisengageDiffLockRqCentralFront SWTST_u8ComRdTc1Sa05DisengageDiffLockRqCentralRear SWTST_u8ComRdTc1Sa05DisengageDiffLockRqFrontAxle1 SWTST_u8ComRdTc1Sa05DisengageDiffLockRqFrontAxle2 SWTST_u8ComRdTc1Sa05DisengageDiffLockRqRearAxle1 SWTST_u8ComRdTc1Sa05DisengageDiffLockRqRearAxle2 SWTST_u8ComRdTc1Sa05DisengageDrivelineRq SWTST_u8ComRdTc1Sa05TransGearShiftInhibitRq SWTST_u8ComRdTc1Sa05TransLoadReductionInhibitRq SWTST_u8ComRdTc1Sa05TransMode1 SWTST_u8ComRdTc1Sa05TransMode2 SWTST_u8ComRdTc1Sa05TransMode3 SWTST_u8ComRdTc1Sa05TransMode4 SWTST_u8ComRdTc1Sa05TransMode5 SWTST_u8ComRdTc1Sa05TransMode6 SWTST_u8ComRdTc1Sa05TransMode7 SWTST_u8ComRdTc1Sa05TransMode8 SWTST_u8ComRdTc1Sa05TransRequestedLaunchGear SWTST_u8ComRdTc1Sa05TransReverseGearShiftInhibitRq SWTST_u8ComRdTc1Sa05TrnsShftSlectorDisplayModeSwitch SWTST_u8ComRdTc1Sa05TrnsTrqeConverterLockupDisableRq SWTST_u8ComRdTc1Sa06AutoNeutralReq SWTST_u8ComRdTc1Sa06Da255AutoNeutralReq SWTST_u8ComRdTc1Sa06Da255DisengageDiffLockRqCentral SWTST_u8ComRdTc1Sa06Da255DisengageDiffLockRqCentralFront SWTST_u8ComRdTc1Sa06Da255DisengageDiffLockRqCentralRear SWTST_u8ComRdTc1Sa06Da255DisengageDiffLockRqFrontAxle1 SWTST_u8ComRdTc1Sa06Da255DisengageDiffLockRqFrontAxle2 SWTST_u8ComRdTc1Sa06Da255DisengageDiffLockRqRearAxle1 SWTST_u8ComRdTc1Sa06Da255DisengageDiffLockRqRearAxle2 SWTST_u8ComRdTc1Sa06Da255DisengageDrivelineRq SWTST_u8ComRdTc1Sa06Da255TransGearShiftInhibitRq SWTST_u8ComRdTc1Sa06Da255TransLoadReductionInhibitRq SWTST_u8ComRdTc1Sa06Da255TransMode1 SWTST_u8ComRdTc1Sa06Da255TransMode2 SWTST_u8ComRdTc1Sa06Da255TransMode3 SWTST_u8ComRdTc1Sa06Da255TransMode4 SWTST_u8ComRdTc1Sa06Da255TransMode5 SWTST_u8ComRdTc1Sa06Da255TransMode6 SWTST_u8ComRdTc1Sa06Da255TransMode7 SWTST_u8ComRdTc1Sa06Da255TransMode8 SWTST_u8ComRdTc1Sa06Da255TransRequestedLaunchGear SWTST_u8ComRdTc1Sa06Da255TransReverseGearShiftInhibitRq SWTST_u8ComRdTc1Sa06Da255TrnsShftSlectorDisplayModeSwitch SWTST_u8ComRdTc1Sa06Da255TrnsTrqeConverterLockupDisableRq SWTST_u8ComRdTc1Sa06DisengageDiffLockRqCentral SWTST_u8ComRdTc1Sa06DisengageDiffLockRqCentralFront SWTST_u8ComRdTc1Sa06DisengageDiffLockRqCentralRear SWTST_u8ComRdTc1Sa06DisengageDiffLockRqFrontAxle1 SWTST_u8ComRdTc1Sa06DisengageDiffLockRqFrontAxle2 SWTST_u8ComRdTc1Sa06DisengageDiffLockRqRearAxle1 SWTST_u8ComRdTc1Sa06DisengageDiffLockRqRearAxle2 SWTST_u8ComRdTc1Sa06DisengageDrivelineRq SWTST_u8ComRdTc1Sa06TransGearShiftInhibitRq SWTST_u8ComRdTc1Sa06TransLoadReductionInhibitRq SWTST_u8ComRdTc1Sa06TransMode1 SWTST_u8ComRdTc1Sa06TransMode2 SWTST_u8ComRdTc1Sa06TransMode3 SWTST_u8ComRdTc1Sa06TransMode4 SWTST_u8ComRdTc1Sa06TransMode5 SWTST_u8ComRdTc1Sa06TransMode6 SWTST_u8ComRdTc1Sa06TransMode7 SWTST_u8ComRdTc1Sa06TransMode8 SWTST_u8ComRdTc1Sa06TransRequestedLaunchGear SWTST_u8ComRdTc1Sa06TransReverseGearShiftInhibitRq SWTST_u8ComRdTc1Sa06TrnsShftSlectorDisplayModeSwitch SWTST_u8ComRdTc1Sa06TrnsTrqeConverterLockupDisableRq SWTST_u8ComRdTc1Sa23AutoNeutralReq SWTST_u8ComRdTc1Sa23Da255AutoNeutralReq SWTST_u8ComRdTc1Sa23Da255DisengageDiffLockRqCentral SWTST_u8ComRdTc1Sa23Da255DisengageDiffLockRqCentralFront SWTST_u8ComRdTc1Sa23Da255DisengageDiffLockRqCentralRear SWTST_u8ComRdTc1Sa23Da255DisengageDiffLockRqFrontAxle1 SWTST_u8ComRdTc1Sa23Da255DisengageDiffLockRqFrontAxle2 SWTST_u8ComRdTc1Sa23Da255DisengageDiffLockRqRearAxle1 SWTST_u8ComRdTc1Sa23Da255DisengageDiffLockRqRearAxle2 SWTST_u8ComRdTc1Sa23Da255DisengageDrivelineRq SWTST_u8ComRdTc1Sa23Da255TransGearShiftInhibitRq SWTST_u8ComRdTc1Sa23Da255TransLoadReductionInhibitRq SWTST_u8ComRdTc1Sa23Da255TransMode1 SWTST_u8ComRdTc1Sa23Da255TransMode2 SWTST_u8ComRdTc1Sa23Da255TransMode3 SWTST_u8ComRdTc1Sa23Da255TransMode4 SWTST_u8ComRdTc1Sa23Da255TransMode5 SWTST_u8ComRdTc1Sa23Da255TransMode6 SWTST_u8ComRdTc1Sa23Da255TransMode7 SWTST_u8ComRdTc1Sa23Da255TransMode8 SWTST_u8ComRdTc1Sa23Da255TransRequestedLaunchGear SWTST_u8ComRdTc1Sa23Da255TransReverseGearShiftInhibitRq SWTST_u8ComRdTc1Sa23Da255TrnsShftSlectorDisplayModeSwitch SWTST_u8ComRdTc1Sa23Da255TrnsTrqeConverterLockupDisableRq SWTST_u8ComRdTc1Sa23DisengageDiffLockRqCentral SWTST_u8ComRdTc1Sa23DisengageDiffLockRqCentralFront SWTST_u8ComRdTc1Sa23DisengageDiffLockRqCentralRear SWTST_u8ComRdTc1Sa23DisengageDiffLockRqFrontAxle1 SWTST_u8ComRdTc1Sa23DisengageDiffLockRqFrontAxle2 SWTST_u8ComRdTc1Sa23DisengageDiffLockRqRearAxle1 SWTST_u8ComRdTc1Sa23DisengageDiffLockRqRearAxle2 SWTST_u8ComRdTc1Sa23DisengageDrivelineRq SWTST_u8ComRdTc1Sa23TransGearShiftInhibitRq SWTST_u8ComRdTc1Sa23TransLoadReductionInhibitRq SWTST_u8ComRdTc1Sa23TransMode1 SWTST_u8ComRdTc1Sa23TransMode2 SWTST_u8ComRdTc1Sa23TransMode3 SWTST_u8ComRdTc1Sa23TransMode4 SWTST_u8ComRdTc1Sa23TransMode5 SWTST_u8ComRdTc1Sa23TransMode6 SWTST_u8ComRdTc1Sa23TransMode7 SWTST_u8ComRdTc1Sa23TransMode8 SWTST_u8ComRdTc1Sa23TransRequestedLaunchGear SWTST_u8ComRdTc1Sa23TransReverseGearShiftInhibitRq SWTST_u8ComRdTc1Sa23TrnsShftSlectorDisplayModeSwitch SWTST_u8ComRdTc1Sa23TrnsTrqeConverterLockupDisableRq SWTST_u8ComRdTc1Sa33AutoNeutralReq SWTST_u8ComRdTc1Sa33Da255AutoNeutralReq SWTST_u8ComRdTc1Sa33Da255DisengageDiffLockRqCentral SWTST_u8ComRdTc1Sa33Da255DisengageDiffLockRqCentralFront SWTST_u8ComRdTc1Sa33Da255DisengageDiffLockRqCentralRear SWTST_u8ComRdTc1Sa33Da255DisengageDiffLockRqFrontAxle1 SWTST_u8ComRdTc1Sa33Da255DisengageDiffLockRqFrontAxle2 SWTST_u8ComRdTc1Sa33Da255DisengageDiffLockRqRearAxle1 SWTST_u8ComRdTc1Sa33Da255DisengageDiffLockRqRearAxle2 SWTST_u8ComRdTc1Sa33Da255DisengageDrivelineRq SWTST_u8ComRdTc1Sa33Da255TransGearShiftInhibitRq SWTST_u8ComRdTc1Sa33Da255TransLoadReductionInhibitRq SWTST_u8ComRdTc1Sa33Da255TransMode1 SWTST_u8ComRdTc1Sa33Da255TransMode2 SWTST_u8ComRdTc1Sa33Da255TransMode3 SWTST_u8ComRdTc1Sa33Da255TransMode4 SWTST_u8ComRdTc1Sa33Da255TransMode5 SWTST_u8ComRdTc1Sa33Da255TransMode6 SWTST_u8ComRdTc1Sa33Da255TransMode7 SWTST_u8ComRdTc1Sa33Da255TransMode8 SWTST_u8ComRdTc1Sa33Da255TransRequestedLaunchGear SWTST_u8ComRdTc1Sa33Da255TransReverseGearShiftInhibitRq SWTST_u8ComRdTc1Sa33Da255TrnsShftSlectorDisplayModeSwitch SWTST_u8ComRdTc1Sa33Da255TrnsTrqeConverterLockupDisableRq SWTST_u8ComRdTc1Sa33DisengageDiffLockRqCentral SWTST_u8ComRdTc1Sa33DisengageDiffLockRqCentralFront SWTST_u8ComRdTc1Sa33DisengageDiffLockRqCentralRear SWTST_u8ComRdTc1Sa33DisengageDiffLockRqFrontAxle1 SWTST_u8ComRdTc1Sa33DisengageDiffLockRqFrontAxle2 SWTST_u8ComRdTc1Sa33DisengageDiffLockRqRearAxle1 SWTST_u8ComRdTc1Sa33DisengageDiffLockRqRearAxle2 SWTST_u8ComRdTc1Sa33DisengageDrivelineRq SWTST_u8ComRdTc1Sa33TransGearShiftInhibitRq SWTST_u8ComRdTc1Sa33TransLoadReductionInhibitRq SWTST_u8ComRdTc1Sa33TransMode1 SWTST_u8ComRdTc1Sa33TransMode2 SWTST_u8ComRdTc1Sa33TransMode3 SWTST_u8ComRdTc1Sa33TransMode4 SWTST_u8ComRdTc1Sa33TransMode5 SWTST_u8ComRdTc1Sa33TransMode6 SWTST_u8ComRdTc1Sa33TransMode7 SWTST_u8ComRdTc1Sa33TransMode8 SWTST_u8ComRdTc1Sa33TransRequestedLaunchGear SWTST_u8ComRdTc1Sa33TransReverseGearShiftInhibitRq SWTST_u8ComRdTc1Sa33TrnsShftSlectorDisplayModeSwitch SWTST_u8ComRdTc1Sa33TrnsTrqeConverterLockupDisableRq SWTST_u8ComRdTc1Sa42AutoNeutralReq SWTST_u8ComRdTc1Sa42Da255AutoNeutralReq SWTST_u8ComRdTc1Sa42Da255DisengageDiffLockRqCentral SWTST_u8ComRdTc1Sa42Da255DisengageDiffLockRqCentralFront SWTST_u8ComRdTc1Sa42Da255DisengageDiffLockRqCentralRear SWTST_u8ComRdTc1Sa42Da255DisengageDiffLockRqFrontAxle1 SWTST_u8ComRdTc1Sa42Da255DisengageDiffLockRqFrontAxle2 SWTST_u8ComRdTc1Sa42Da255DisengageDiffLockRqRearAxle1 SWTST_u8ComRdTc1Sa42Da255DisengageDiffLockRqRearAxle2 SWTST_u8ComRdTc1Sa42Da255DisengageDrivelineRq SWTST_u8ComRdTc1Sa42Da255TransGearShiftInhibitRq SWTST_u8ComRdTc1Sa42Da255TransLoadReductionInhibitRq SWTST_u8ComRdTc1Sa42Da255TransMode1 SWTST_u8ComRdTc1Sa42Da255TransMode2 SWTST_u8ComRdTc1Sa42Da255TransMode3 SWTST_u8ComRdTc1Sa42Da255TransMode4 SWTST_u8ComRdTc1Sa42Da255TransMode5 SWTST_u8ComRdTc1Sa42Da255TransMode6 SWTST_u8ComRdTc1Sa42Da255TransMode7 SWTST_u8ComRdTc1Sa42Da255TransMode8 SWTST_u8ComRdTc1Sa42Da255TransRequestedLaunchGear SWTST_u8ComRdTc1Sa42Da255TransReverseGearShiftInhibitRq SWTST_u8ComRdTc1Sa42Da255TrnsShftSlectorDisplayModeSwitch SWTST_u8ComRdTc1Sa42Da255TrnsTrqeConverterLockupDisableRq SWTST_u8ComRdTc1Sa42DisengageDiffLockRqCentral SWTST_u8ComRdTc1Sa42DisengageDiffLockRqCentralFront SWTST_u8ComRdTc1Sa42DisengageDiffLockRqCentralRear SWTST_u8ComRdTc1Sa42DisengageDiffLockRqFrontAxle1 SWTST_u8ComRdTc1Sa42DisengageDiffLockRqFrontAxle2 SWTST_u8ComRdTc1Sa42DisengageDiffLockRqRearAxle1 SWTST_u8ComRdTc1Sa42DisengageDiffLockRqRearAxle2 SWTST_u8ComRdTc1Sa42DisengageDrivelineRq SWTST_u8ComRdTc1Sa42TransGearShiftInhibitRq SWTST_u8ComRdTc1Sa42TransLoadReductionInhibitRq SWTST_u8ComRdTc1Sa42TransMode1 SWTST_u8ComRdTc1Sa42TransMode2 SWTST_u8ComRdTc1Sa42TransMode3 SWTST_u8ComRdTc1Sa42TransMode4 SWTST_u8ComRdTc1Sa42TransMode5 SWTST_u8ComRdTc1Sa42TransMode6 SWTST_u8ComRdTc1Sa42TransMode7 SWTST_u8ComRdTc1Sa42TransMode8 SWTST_u8ComRdTc1Sa42TransRequestedLaunchGear SWTST_u8ComRdTc1Sa42TransReverseGearShiftInhibitRq SWTST_u8ComRdTc1Sa42TrnsShftSlectorDisplayModeSwitch SWTST_u8ComRdTc1Sa42TrnsTrqeConverterLockupDisableRq SWTST_u8ComRdTc1Sa49AutoNeutralReq SWTST_u8ComRdTc1Sa49Da255AutoNeutralReq SWTST_u8ComRdTc1Sa49Da255DisengageDiffLockRqCentral SWTST_u8ComRdTc1Sa49Da255DisengageDiffLockRqCentralFront SWTST_u8ComRdTc1Sa49Da255DisengageDiffLockRqCentralRear SWTST_u8ComRdTc1Sa49Da255DisengageDiffLockRqFrontAxle1 SWTST_u8ComRdTc1Sa49Da255DisengageDiffLockRqFrontAxle2 SWTST_u8ComRdTc1Sa49Da255DisengageDiffLockRqRearAxle1 SWTST_u8ComRdTc1Sa49Da255DisengageDiffLockRqRearAxle2 SWTST_u8ComRdTc1Sa49Da255DisengageDrivelineRq SWTST_u8ComRdTc1Sa49Da255TransGearShiftInhibitRq SWTST_u8ComRdTc1Sa49Da255TransLoadReductionInhibitRq SWTST_u8ComRdTc1Sa49Da255TransMode1 SWTST_u8ComRdTc1Sa49Da255TransMode2 SWTST_u8ComRdTc1Sa49Da255TransMode3 SWTST_u8ComRdTc1Sa49Da255TransMode4 SWTST_u8ComRdTc1Sa49Da255TransMode5 SWTST_u8ComRdTc1Sa49Da255TransMode6 SWTST_u8ComRdTc1Sa49Da255TransMode7 SWTST_u8ComRdTc1Sa49Da255TransMode8 SWTST_u8ComRdTc1Sa49Da255TransRequestedLaunchGear SWTST_u8ComRdTc1Sa49Da255TransReverseGearShiftInhibitRq SWTST_u8ComRdTc1Sa49Da255TrnsShftSlectorDisplayModeSwitch SWTST_u8ComRdTc1Sa49Da255TrnsTrqeConverterLockupDisableRq SWTST_u8ComRdTc1Sa49DisengageDiffLockRqCentral SWTST_u8ComRdTc1Sa49DisengageDiffLockRqCentralFront SWTST_u8ComRdTc1Sa49DisengageDiffLockRqCentralRear SWTST_u8ComRdTc1Sa49DisengageDiffLockRqFrontAxle1 SWTST_u8ComRdTc1Sa49DisengageDiffLockRqFrontAxle2 SWTST_u8ComRdTc1Sa49DisengageDiffLockRqRearAxle1 SWTST_u8ComRdTc1Sa49DisengageDiffLockRqRearAxle2 SWTST_u8ComRdTc1Sa49DisengageDrivelineRq SWTST_u8ComRdTc1Sa49TransGearShiftInhibitRq SWTST_u8ComRdTc1Sa49TransLoadReductionInhibitRq SWTST_u8ComRdTc1Sa49TransMode1 SWTST_u8ComRdTc1Sa49TransMode2 SWTST_u8ComRdTc1Sa49TransMode3 SWTST_u8ComRdTc1Sa49TransMode4 SWTST_u8ComRdTc1Sa49TransMode5 SWTST_u8ComRdTc1Sa49TransMode6 SWTST_u8ComRdTc1Sa49TransMode7 SWTST_u8ComRdTc1Sa49TransMode8 SWTST_u8ComRdTc1Sa49TransRequestedLaunchGear SWTST_u8ComRdTc1Sa49TransReverseGearShiftInhibitRq SWTST_u8ComRdTc1Sa49TrnsShftSlectorDisplayModeSwitch SWTST_u8ComRdTc1Sa49TrnsTrqeConverterLockupDisableRq SWTST_u8ComRdTsc1Sa00EngOverrideCtrlMode SWTST_u8ComRdTsc1Sa00EngRequestedSpeedCtrlConditions SWTST_u8ComRdTsc1Sa00MessageChecksum SWTST_u8ComRdTsc1Sa00MessageCounter SWTST_u8ComRdTsc1Sa00OverrideCtrlModePriority SWTST_u8ComRdTsc1Sa00TSC1CtrlPurpose SWTST_u8ComRdTsc1Sa00TSC1TransRate SWTST_u8ComRdTsc1Sa11EngOverrideCtrlMode SWTST_u8ComRdTsc1Sa11EngRequestedSpeedCtrlConditions SWTST_u8ComRdTsc1Sa11MessageChecksum SWTST_u8ComRdTsc1Sa11MessageCounter SWTST_u8ComRdTsc1Sa11OverrideCtrlModePriority SWTST_u8ComRdTsc1Sa11TSC1CtrlPurpose SWTST_u8ComRdTsc1Sa11TSC1TransRate SWTST_u8ComRdTsc1Sa17EngOverrideCtrlMode SWTST_u8ComRdTsc1Sa17EngRequestedSpeedCtrlConditions SWTST_u8ComRdTsc1Sa17MessageChecksum SWTST_u8ComRdTsc1Sa17MessageCounter SWTST_u8ComRdTsc1Sa17OverrideCtrlModePriority SWTST_u8ComRdTsc1Sa17TSC1CtrlPurpose SWTST_u8ComRdTsc1Sa17TSC1TransRate SWTST_u8ComRdTsc1Sa33EngOverrideCtrlMode SWTST_u8ComRdTsc1Sa33EngRequestedSpeedCtrlConditions SWTST_u8ComRdTsc1Sa33MessageChecksum SWTST_u8ComRdTsc1Sa33MessageCounter SWTST_u8ComRdTsc1Sa33OverrideCtrlModePriority SWTST_u8ComRdTsc1Sa33TSC1CtrlPurpose SWTST_u8ComRdTsc1Sa33TSC1TransRate SWTST_u8ComRdTsc1Sa39EngOverrideCtrlMode SWTST_u8ComRdTsc1Sa39EngRequestedSpeedCtrlConditions SWTST_u8ComRdTsc1Sa39MessageChecksum SWTST_u8ComRdTsc1Sa39MessageCounter SWTST_u8ComRdTsc1Sa39OverrideCtrlModePriority SWTST_u8ComRdTsc1Sa39TSC1CtrlPurpose SWTST_u8ComRdTsc1Sa39TSC1TransRate SWTST_u8ComRdTsc1Sa42EngOverrideCtrlMode SWTST_u8ComRdTsc1Sa42EngRequestedSpeedCtrlConditions SWTST_u8ComRdTsc1Sa42MessageChecksum SWTST_u8ComRdTsc1Sa42MessageCounter SWTST_u8ComRdTsc1Sa42OverrideCtrlModePriority SWTST_u8ComRdTsc1Sa42TSC1CtrlPurpose SWTST_u8ComRdTsc1Sa42TSC1TransRate SWTST_u8ComResumeTstNr SWTST_u8ComTstDoneNr SWTST_u8ComTstErrId SWTST_u8ComTstNrNm1 SWTST_u8DcmInfotype04RespFlag SWTST_u8DcmInfotype06RespFlag SWTST_u8DcmInfotype0ARespFlag SWTST_u8DiagcAnIptFltTst SWTST_u8DiagcAnIptFltTst[0][0] SWTST_u8DiagcAnIptFltTst[0][1] SWTST_u8DiagcAnIptFltTst[0][2] SWTST_u8DiagcAnIptFltTst[0][3] SWTST_u8DiagcAnIptFltTst[0][4] SWTST_u8DiagcAnIptFltTst[0][5] SWTST_u8DiagcAnIptFltTst[0][6] SWTST_u8DiagcAnIptFltTst[0][7] SWTST_u8DiagcAnIptFltTst[0][8] SWTST_u8DiagcAnIptFltTst[1][0] SWTST_u8DiagcAnIptFltTst[1][1] SWTST_u8DiagcAnIptFltTst[1][2] SWTST_u8DiagcAnIptFltTst[1][3] SWTST_u8DiagcAnIptFltTst[1][4] SWTST_u8DiagcAnIptFltTst[1][5] SWTST_u8DiagcAnIptFltTst[1][6] SWTST_u8DiagcAnIptFltTst[1][7] SWTST_u8DiagcAnIptFltTst[1][8] SWTST_u8DiagcBRAKE_AND_ABS SWTST_u8DiagcCAN1BusOff SWTST_u8DiagcCAN2BusOff SWTST_u8DiagcCAN3BusOff SWTST_u8DiagcCCVS1_RX_SA_00_SPN84ErrValDiagc SWTST_u8DiagcCCVS1_RX_SA_00ErrValDiagc SWTST_u8DiagcCCVS1_RX_SA_17_SPN84ErrValDiagc SWTST_u8DiagcCCVS1_RX_SA_232_SPN84ErrValDiagc SWTST_u8DiagcCCVS1_RX_SA_23_SPN84ErrValDiagc SWTST_u8DiagcCCVS1_RX_SA_33_SPN84ErrValDiagc SWTST_u8DiagcCCVS1_RX_SA_39_SPN84ErrValDiagc SWTST_u8DiagcCCVS1_RX_SA_49_SPN84ErrValDiagc SWTST_u8DiagcCheckSumTst SWTST_u8DiagcEBC1_RX_SA_00_SPN521ErrValDiagc SWTST_u8DiagcEBC1_RX_SA_00SigErrValDiagc SWTST_u8DiagcEBC1_RX_SA_11_SPN521ErrValDiagc SWTST_u8DiagcEBC1_RX_SA_23_SPN521ErrValDiagc SWTST_u8DiagcEBC1_RX_SA_33_SPN521ErrValDiagc SWTST_u8DiagcEBC1_RX_SA_49_SPN521ErrValDiagc SWTST_u8DiagcEC1_RX_SA_00_SPN544ErrValDiagc SWTST_u8DiagcEC1_RX_SA_00ErrValDiagc544 SWTST_u8DiagcEEC1_RX_SA_00_SPN190ErrValDiagc SWTST_u8DiagcEEC1_RX_SA_00_SPN513ErrValDiagc SWTST_u8DiagcEEC1_RX_SA_00ErrValDiagc SWTST_u8DiagcEEC1_RX_SA_00ErrValDiagc513 SWTST_u8DiagcEEC2_RX_SA_00_SPN29ErrValDiagc SWTST_u8DiagcEEC2_RX_SA_00_SPN91ErrValDiagc SWTST_u8DiagcEEC2_RX_SA_00ErrValDiagc29 SWTST_u8DiagcEEC2_RX_SA_00ErrValDiagc91 SWTST_u8DiagcEEC2_RX_SA_17_SPN29ErrValDiagc SWTST_u8DiagcEEC2_RX_SA_17_SPN91ErrValDiagc SWTST_u8DiagcEEC2_RX_SA_33_SPN29ErrValDiagc SWTST_u8DiagcEEC2_RX_SA_33_SPN91ErrValDiagc SWTST_u8DiagcEEC2_RX_SA_49_SPN29ErrValDiagc SWTST_u8DiagcEEC2_RX_SA_49_SPN91ErrValDiagc SWTST_u8DiagcEepromFlt SWTST_u8DiagcENGINE_COOLANT SWTST_u8DiagcENGINE_SPEED SWTST_u8DiagcENGINE_TORQUE513 SWTST_u8DiagcENGINE_TORQUE544 SWTST_u8DiagcERC1_RX_SA_00_SPN1716ErrValDiagc SWTST_u8DiagcERC1_RX_SA_00_SPN520ErrValDiagc SWTST_u8DiagcERC1_RX_SA_00_SPN571ErrValDiagc SWTST_u8DiagcERC1_RX_SA_00ErrValDiagc1716 SWTST_u8DiagcERC1_RX_SA_00ErrValDiagc520 SWTST_u8DiagcERC1_RX_SA_00ErrValDiagc571 SWTST_u8DiagcERC1_RX_SA_15_SPN1716ErrValDiagc SWTST_u8DiagcERC1_RX_SA_15_SPN520ErrValDiagc SWTST_u8DiagcERC1_RX_SA_15_SPN571ErrValDiagc SWTST_u8DiagcERC1_RX_SA_23_SPN1716ErrValDiagc SWTST_u8DiagcERC1_RX_SA_23_SPN520ErrValDiagc SWTST_u8DiagcERC1_RX_SA_23_SPN571ErrValDiagc SWTST_u8DiagcERC1_RX_SA_33_SPN1716ErrValDiagc SWTST_u8DiagcERC1_RX_SA_33_SPN520ErrValDiagc SWTST_u8DiagcERC1_RX_SA_33_SPN571ErrValDiagc SWTST_u8DiagcERC1_RX_SA_41_SPN1716ErrValDiagc SWTST_u8DiagcERC1_RX_SA_41_SPN520ErrValDiagc SWTST_u8DiagcERC1_RX_SA_41_SPN571ErrValDiagc SWTST_u8DiagcERC1_RX_SA_49_SPN1716ErrValDiagc SWTST_u8DiagcERC1_RX_SA_49_SPN520ErrValDiagc SWTST_u8DiagcERC1_RX_SA_49_SPN571ErrValDiagc SWTST_u8DiagcET1_RX_SA_00_SPN110ErrValDiagc SWTST_u8DiagcET1_RX_SA_00ErrValDiagc SWTST_u8DiagcFspSt SWTST_u8DiagcMsgIdx SWTST_u8DiagcPEDAL_SIGNAL29 SWTST_u8DiagcPEDAL_SIGNAL91 SWTST_u8DiagcPTO_SWITCH SWTST_u8DiagcPTODE_RX_SA_23_SPN3454ErrValDiagc SWTST_u8DiagcPTODE_RX_SA_23ErrValDiagc SWTST_u8DiagcPTODE_RX_SA_33_SPN3454ErrValDiagc SWTST_u8DiagcPTODE_RX_SA_49_SPN3454ErrValDiagc SWTST_u8DiagcPwmIptFltTst SWTST_u8DiagcPwmIptFltTst[0][0] SWTST_u8DiagcPwmIptFltTst[0][1] SWTST_u8DiagcPwmIptFltTst[1][0] SWTST_u8DiagcPwmIptFltTst[1][1] SWTST_u8DiagcPwmIptFltTst[2][0] SWTST_u8DiagcPwmIptFltTst[2][1] SWTST_u8DiagcRamTstFlt SWTST_u8DiagcResetCircuitFlt SWTST_u8DiagcResumeTstNr SWTST_u8DiagcRETARDER_COMMAND1716 SWTST_u8DiagcRETARDER_COMMAND520 SWTST_u8DiagcRETARDER_COMMAND571 SWTST_u8DiagcSpdFltTst SWTST_u8DiagcSpdFltTst[0][0] SWTST_u8DiagcSpdFltTst[0][1] SWTST_u8DiagcSpdFltTst[0][2] SWTST_u8DiagcSpdFltTst[0][3] SWTST_u8DiagcSpdFltTst[0][4] SWTST_u8DiagcSpdFltTst[0][5] SWTST_u8DiagcSpdFltTst[1][0] SWTST_u8DiagcSpdFltTst[1][1] SWTST_u8DiagcSpdFltTst[1][2] SWTST_u8DiagcSpdFltTst[1][3] SWTST_u8DiagcSpdFltTst[1][4] SWTST_u8DiagcSpdFltTst[1][5] SWTST_u8DiagcSpdoScFlt SWTST_u8DiagcSpdoScsFlt SWTST_u8DiagcSplyFltTst SWTST_u8DiagcSplyFltTst[0][0] SWTST_u8DiagcSplyFltTst[0][1] SWTST_u8DiagcSplyFltTst[0][2] SWTST_u8DiagcSplyFltTst[0][3] SWTST_u8DiagcSplyFltTst[0][4] SWTST_u8DiagcSplyFltTst[1][0] SWTST_u8DiagcSplyFltTst[1][1] SWTST_u8DiagcSplyFltTst[1][2] SWTST_u8DiagcSplyFltTst[1][3] SWTST_u8DiagcSplyFltTst[1][4] SWTST_u8DiagcSplyFltTst[2][0] SWTST_u8DiagcSplyFltTst[2][1] SWTST_u8DiagcSplyFltTst[2][2] SWTST_u8DiagcSplyFltTst[2][3] SWTST_u8DiagcSplyFltTst[2][4] SWTST_u8DiagcSplyFltTst[3][0] SWTST_u8DiagcSplyFltTst[3][1] SWTST_u8DiagcSplyFltTst[3][2] SWTST_u8DiagcSplyFltTst[3][3] SWTST_u8DiagcSplyFltTst[3][4] SWTST_u8DiagcSplyHiFlt SWTST_u8DiagcSplyLoFlt SWTST_u8DiagcTC1_RX_SA_05_Global_DA_SPN525ErrValDiagc SWTST_u8DiagcTC1_RX_SA_05_SPN525ErrValDiagc SWTST_u8DiagcTC1_RX_SA_05ErrValDiagc SWTST_u8DiagcTC1_RX_SA_06_Global_DA_SPN525ErrValDiagc SWTST_u8DiagcTC1_RX_SA_06_SPN525ErrValDiagc SWTST_u8DiagcTC1_RX_SA_23_Global_DA_SPN525ErrValDiagc SWTST_u8DiagcTC1_RX_SA_23_SPN525ErrValDiagc SWTST_u8DiagcTC1_RX_SA_33_Global_DA_SPN525ErrValDiagc SWTST_u8DiagcTC1_RX_SA_33_SPN525ErrValDiagc SWTST_u8DiagcTC1_RX_SA_42_Global_DA_SPN525ErrValDiagc SWTST_u8DiagcTC1_RX_SA_42_SPN525ErrValDiagc SWTST_u8DiagcTC1_RX_SA_49_Global_DA_SPN525ErrValDiagc SWTST_u8DiagcTC1_RX_SA_49_SPN525ErrValDiagc SWTST_u8DiagcTstDoneNr SWTST_u8DiagcTstErrId SWTST_u8DiagcTstNrNm1 SWTST_u8DiagcVEHICLE_SPEED SWTST_u8DioResumeTstNr SWTST_u8DioTstDoneNr SWTST_u8DioTstErrId SWTST_u8DioTstNrNm1 SWTST_u8FimResumeTstNr SWTST_u8FimTstDoneNr SWTST_u8FimTstErrId SWTST_u8FimTstNrNm1 SWTST_u8Lvl2RamCrcTstNr SWTST_u8SftyResumeTstNr SWTST_u8SftyRstCntr SWTST_u8SftyTstDoneNr SWTST_u8SftyTstErrId SWTST_u8SftyTstNrNm1 SWTST_u8Tle62X0ResumeTstNr SWTST_u8Tle62X0TstDoneNr SWTST_u8Tle62X0TstErrId SWTST_u8Tle62X0TstNrNm1 SWTST_u8Tle8242ReadOpenLoopLnrVlv1_1 SWTST_u8Tle8242ReadOpenLoopLnrVlv1_2 SWTST_u8Tle8242ReadOpenLoopLnrVlv2_3 SWTST_u8Tle8242ReadOpenLoopLnrVlv2_4 SWTST_u8Tle8242ReadOpenLoopLnrVlv2_5 SWTST_u8Tle8242ReadOpenLoopLnrVlv3_6 SWTST_u8Tle8242ReadOpenLoopLnrVlv3_7 SWTST_u8Tle8242ReadOpenLoopLnrVlv3_8 SWTST_u8Tle8242ReadOpenLoopLnrVlv4_10 SWTST_u8Tle8242ReadOpenLoopLnrVlv4_9 SWTST_u8Tle8242ReadOpenLoopPwmVlv1_1 SWTST_u8Tle8242ReadOpenLoopPwmVlv1_2 SWTST_u8Tle8242ReadOpenLoopPwmVlv1_3 SWTST_u8Tle8242ReadOpenLoopPwmVlv4_4 SWTST_u8Tle8242ReadOpenLoopPwmVlv4_5 SWTST_u8Tle8242ResumeTstNr SWTST_u8Tle8242TstDoneNr SWTST_u8Tle8242TstErrId SWTST_u8Tle8242TstNrNm1 SWTST_u8Tle8242WrOpenLoopLnrVlv1_1 SWTST_u8Tle8242WrOpenLoopLnrVlv1_2 SWTST_u8Tle8242WrOpenLoopLnrVlv2_3 SWTST_u8Tle8242WrOpenLoopLnrVlv2_4 SWTST_u8Tle8242WrOpenLoopLnrVlv2_5 SWTST_u8Tle8242WrOpenLoopLnrVlv3_6 SWTST_u8Tle8242WrOpenLoopLnrVlv3_7 SWTST_u8Tle8242WrOpenLoopLnrVlv3_8 SWTST_u8Tle8242WrOpenLoopLnrVlv4_9 SWTST_u8Tle8242WrOpenLoopPwmVlv1_1 SWTST_u8Tle8242WrOpenLoopPwmVlv1_2 SWTST_u8Tle8242WrOpenLoopPwmVlv1_3 SWTST_u8Tle8242WrOpenLoopPwmVlv4_4 SWTST_u8Tle8242WrOpenLoopPwmVlv4_5 SWTST_u8TrimResumeTstNr SWTST_u8TrimTstDoneNr SWTST_u8TrimTstErrId SWTST_u8TrimTstNrNm1 SWTST_u8WdgResumeTstNr SWTST_u8WdgTstDoneNr SWTST_u8WdgTstErrId SWTST_u8WdgTstNrNm1 SWTST_udtDcmCallBackDidFor2fRd0200 SWTST_udtDcmCallBackDidFor2fRd0201 SWTST_udtDcmCallBackDidFor2fRd0202 SWTST_udtDcmCallBackDidFor2fRd0203 SWTST_udtDcmCallBackDidFor2fRd0204 SWTST_udtDcmCallBackDidFor2fRd0205 SWTST_udtDcmCallBackDidFor2fRd0206 SWTST_udtDcmCallBackDidFor2fRd0207 SWTST_udtDcmCallBackDidFor2fRd0208 SWTST_udtDcmCallBackDidFor2fRd0209 SWTST_udtDcmCallBackDidFor2fRdErrCode0200 SWTST_udtDcmCallBackDidFor2fRdErrCode0201 SWTST_udtDcmCallBackDidFor2fRdErrCode0202 SWTST_udtDcmCallBackDidFor2fRdErrCode0203 SWTST_udtDcmCallBackDidFor2fRdErrCode0204 SWTST_udtDcmCallBackDidFor2fRdErrCode0205 SWTST_udtDcmCallBackDidFor2fRdErrCode0206 SWTST_udtDcmCallBackDidFor2fRdErrCode0207 SWTST_udtDcmCallBackDidFor2fRdErrCode0208 SWTST_udtDcmCallBackDidFor2fRdErrCode0209 SWTST_udtDcmCallBackDidFor2fRetContrl0200 SWTST_udtDcmCallBackDidFor2fRetContrl0201 SWTST_udtDcmCallBackDidFor2fRetContrl0202 SWTST_udtDcmCallBackDidFor2fRetContrl0203 SWTST_udtDcmCallBackDidFor2fRetContrl0204 SWTST_udtDcmCallBackDidFor2fRetContrl0205 SWTST_udtDcmCallBackDidFor2fRetContrl0206 SWTST_udtDcmCallBackDidFor2fRetContrl0207 SWTST_udtDcmCallBackDidFor2fRetContrl0208 SWTST_udtDcmCallBackDidFor2fRetContrl0209 SWTST_udtDcmCallBackDidFor2fRetContrlErrCode0200 SWTST_udtDcmCallBackDidFor2fRetContrlErrCode0201 SWTST_udtDcmCallBackDidFor2fRetContrlErrCode0202 SWTST_udtDcmCallBackDidFor2fRetContrlErrCode0203 SWTST_udtDcmCallBackDidFor2fRetContrlErrCode0204 SWTST_udtDcmCallBackDidFor2fRetContrlErrCode0205 SWTST_udtDcmCallBackDidFor2fRetContrlErrCode0206 SWTST_udtDcmCallBackDidFor2fRetContrlErrCode0207 SWTST_udtDcmCallBackDidFor2fRetContrlErrCode0208 SWTST_udtDcmCallBackDidFor2fRetContrlErrCode0209 SWTST_udtDcmCallBackDidFor2fShortContrl0200 SWTST_udtDcmCallBackDidFor2fShortContrl0201 SWTST_udtDcmCallBackDidFor2fShortContrl0202 SWTST_udtDcmCallBackDidFor2fShortContrl0203 SWTST_udtDcmCallBackDidFor2fShortContrl0204 SWTST_udtDcmCallBackDidFor2fShortContrl0205 SWTST_udtDcmCallBackDidFor2fShortContrl0206 SWTST_udtDcmCallBackDidFor2fShortContrl0207 SWTST_udtDcmCallBackDidFor2fShortContrl0208 SWTST_udtDcmCallBackDidFor2fShortContrl0209 SWTST_udtDcmCallBackDidFor2fShortContrlErrCode0200 SWTST_udtDcmCallBackDidFor2fShortContrlErrCode0201 SWTST_udtDcmCallBackDidFor2fShortContrlErrCode0202 SWTST_udtDcmCallBackDidFor2fShortContrlErrCode0203 SWTST_udtDcmCallBackDidFor2fShortContrlErrCode0204 SWTST_udtDcmCallBackDidFor2fShortContrlErrCode0205 SWTST_udtDcmCallBackDidFor2fShortContrlErrCode0206 SWTST_udtDcmCallBackDidFor2fShortContrlErrCode0207 SWTST_udtDcmCallBackDidFor2fShortContrlErrCode0208 SWTST_udtDcmCallBackDidFor2fShortContrlErrCode0209 SWTST_udtDcmCallBackDidFor31ReqResDF00 SWTST_udtDcmCallBackDidFor31ReqResDF01 SWTST_udtDcmCallBackDidFor31ReqResDF02 SWTST_udtDcmCallBackDidFor31ReqResErrCodeDF00 SWTST_udtDcmCallBackDidFor31ReqResErrCodeDF01 SWTST_udtDcmCallBackDidFor31ReqResErrCodeDF02 SWTST_udtDcmCallBackDidFor31StartErrCodeDF00 SWTST_udtDcmCallBackDidFor31StartErrCodeDF01 SWTST_udtDcmCallBackDidFor31StartErrCodeDF02 SWTST_udtDcmCallBackDidFor31StartFlagDF00 SWTST_udtDcmCallBackDidFor31StartFlagDF01 SWTST_udtDcmCallBackDidFor31StartFlagDF02 SWTST_udtDcmCallBackDidForffRdFF02 SWTST_udtDcmCallBackDidForffRdFF04 SWTST_udtDcmCallBackDidForffRdFF05 SWTST_udtDcmCallBackDidForffRdFF0C SWTST_udtDcmCallBackDidForffRdFF0D SWTST_udtDcmCallBackDidForffRdFF42 SWTST_udtDcmCallBackDidForffRdFF49 SWTST_udtDcmCallBackDidForffRdFF61 SWTST_udtDcmCallBackDidForffRdFF62 SWTST_udtDcmCallBackDidForffRdFF63 SWTST_udtDcmCallBackDidForffRdFF64 SWTST_udtDcmCallBackDidForffRdFF65 SWTST_udtDcmCallBackDidForffRdFF66 SWTST_udtDcmCallBackDidForffRdFF67 SWTST_udtDcmCallBackDidForffRdFF68 SWTST_udtDcmCallBackDidForffRdFF69 SWTST_udtDcmCallBackDidForffRdFF6A SWTST_udtDcmCallBackDidForffRdFF6B SWTST_udtDcmCallBackDidForffRdFF6C SWTST_udtDcmCallBackDidForffRdFF6D SWTST_udtDcmCallBackDidForffRdFF6E SWTST_udtDcmCallBackDidForffRdFF6F SWTST_udtDcmCallBackDidForffRdFF71 SWTST_udtDcmCallBackDidForffRdFF72 SWTST_udtDcmCallBackDidForRd0100 SWTST_udtDcmCallBackDidForRd0101 SWTST_udtDcmCallBackDidForRd0102 SWTST_udtDcmCallBackDidForRd0103 SWTST_udtDcmCallBackDidForRd0104 SWTST_udtDcmCallBackDidForRd0105 SWTST_udtDcmCallBackDidForRd0106 SWTST_udtDcmCallBackDidForRd0107 SWTST_udtDcmCallBackDidForRd0108 SWTST_udtDcmCallBackDidForRd0109 SWTST_udtDcmCallBackDidForRd010A SWTST_udtDcmCallBackDidForRd010B SWTST_udtDcmCallBackDidForRd010C SWTST_udtDcmCallBackDidForRd010D SWTST_udtDcmCallBackDidForRd010E SWTST_udtDcmCallBackDidForRd010F SWTST_udtDcmCallBackDidForRd0110 SWTST_udtDcmCallBackDidForRd0111 SWTST_udtDcmCallBackDidForRd0112 SWTST_udtDcmCallBackDidForRd0113 SWTST_udtDcmCallBackDidForRd0114 SWTST_udtDcmCallBackDidForRd0115 SWTST_udtDcmCallBackDidForRd0116 SWTST_udtDcmCallBackDidForRd0130 SWTST_udtDcmCallBackDidForRd0130[0] SWTST_udtDcmCallBackDidForRd0130[10] SWTST_udtDcmCallBackDidForRd0130[11] SWTST_udtDcmCallBackDidForRd0130[12] SWTST_udtDcmCallBackDidForRd0130[13] SWTST_udtDcmCallBackDidForRd0130[14] SWTST_udtDcmCallBackDidForRd0130[15] SWTST_udtDcmCallBackDidForRd0130[16] SWTST_udtDcmCallBackDidForRd0130[1] SWTST_udtDcmCallBackDidForRd0130[2] SWTST_udtDcmCallBackDidForRd0130[3] SWTST_udtDcmCallBackDidForRd0130[4] SWTST_udtDcmCallBackDidForRd0130[5] SWTST_udtDcmCallBackDidForRd0130[6] SWTST_udtDcmCallBackDidForRd0130[7] SWTST_udtDcmCallBackDidForRd0130[8] SWTST_udtDcmCallBackDidForRd0130[9] SWTST_udtDcmCallBackDidForRd0300 SWTST_udtDcmCallBackDidForRd0300[0] SWTST_udtDcmCallBackDidForRd0300[100] SWTST_udtDcmCallBackDidForRd0300[101] SWTST_udtDcmCallBackDidForRd0300[102] SWTST_udtDcmCallBackDidForRd0300[103] SWTST_udtDcmCallBackDidForRd0300[104] SWTST_udtDcmCallBackDidForRd0300[105] SWTST_udtDcmCallBackDidForRd0300[106] SWTST_udtDcmCallBackDidForRd0300[107] SWTST_udtDcmCallBackDidForRd0300[108] SWTST_udtDcmCallBackDidForRd0300[109] SWTST_udtDcmCallBackDidForRd0300[10] SWTST_udtDcmCallBackDidForRd0300[110] SWTST_udtDcmCallBackDidForRd0300[111] SWTST_udtDcmCallBackDidForRd0300[112] SWTST_udtDcmCallBackDidForRd0300[113] SWTST_udtDcmCallBackDidForRd0300[114] SWTST_udtDcmCallBackDidForRd0300[115] SWTST_udtDcmCallBackDidForRd0300[116] SWTST_udtDcmCallBackDidForRd0300[117] SWTST_udtDcmCallBackDidForRd0300[118] SWTST_udtDcmCallBackDidForRd0300[119] SWTST_udtDcmCallBackDidForRd0300[11] SWTST_udtDcmCallBackDidForRd0300[120] SWTST_udtDcmCallBackDidForRd0300[121] SWTST_udtDcmCallBackDidForRd0300[122] SWTST_udtDcmCallBackDidForRd0300[123] SWTST_udtDcmCallBackDidForRd0300[124] SWTST_udtDcmCallBackDidForRd0300[125] SWTST_udtDcmCallBackDidForRd0300[126] SWTST_udtDcmCallBackDidForRd0300[127] SWTST_udtDcmCallBackDidForRd0300[128] SWTST_udtDcmCallBackDidForRd0300[129] SWTST_udtDcmCallBackDidForRd0300[12] SWTST_udtDcmCallBackDidForRd0300[130] SWTST_udtDcmCallBackDidForRd0300[131] SWTST_udtDcmCallBackDidForRd0300[132] SWTST_udtDcmCallBackDidForRd0300[133] SWTST_udtDcmCallBackDidForRd0300[134] SWTST_udtDcmCallBackDidForRd0300[135] SWTST_udtDcmCallBackDidForRd0300[136] SWTST_udtDcmCallBackDidForRd0300[137] SWTST_udtDcmCallBackDidForRd0300[138] SWTST_udtDcmCallBackDidForRd0300[139] SWTST_udtDcmCallBackDidForRd0300[13] SWTST_udtDcmCallBackDidForRd0300[140] SWTST_udtDcmCallBackDidForRd0300[141] SWTST_udtDcmCallBackDidForRd0300[142] SWTST_udtDcmCallBackDidForRd0300[143] SWTST_udtDcmCallBackDidForRd0300[144] SWTST_udtDcmCallBackDidForRd0300[145] SWTST_udtDcmCallBackDidForRd0300[146] SWTST_udtDcmCallBackDidForRd0300[147] SWTST_udtDcmCallBackDidForRd0300[148] SWTST_udtDcmCallBackDidForRd0300[149] SWTST_udtDcmCallBackDidForRd0300[14] SWTST_udtDcmCallBackDidForRd0300[150] SWTST_udtDcmCallBackDidForRd0300[151] SWTST_udtDcmCallBackDidForRd0300[152] SWTST_udtDcmCallBackDidForRd0300[153] SWTST_udtDcmCallBackDidForRd0300[154] SWTST_udtDcmCallBackDidForRd0300[155] SWTST_udtDcmCallBackDidForRd0300[156] SWTST_udtDcmCallBackDidForRd0300[157] SWTST_udtDcmCallBackDidForRd0300[158] SWTST_udtDcmCallBackDidForRd0300[159] SWTST_udtDcmCallBackDidForRd0300[15] SWTST_udtDcmCallBackDidForRd0300[16] SWTST_udtDcmCallBackDidForRd0300[17] SWTST_udtDcmCallBackDidForRd0300[18] SWTST_udtDcmCallBackDidForRd0300[19] SWTST_udtDcmCallBackDidForRd0300[1] SWTST_udtDcmCallBackDidForRd0300[20] SWTST_udtDcmCallBackDidForRd0300[21] SWTST_udtDcmCallBackDidForRd0300[22] SWTST_udtDcmCallBackDidForRd0300[23] SWTST_udtDcmCallBackDidForRd0300[24] SWTST_udtDcmCallBackDidForRd0300[25] SWTST_udtDcmCallBackDidForRd0300[26] SWTST_udtDcmCallBackDidForRd0300[27] SWTST_udtDcmCallBackDidForRd0300[28] SWTST_udtDcmCallBackDidForRd0300[29] SWTST_udtDcmCallBackDidForRd0300[2] SWTST_udtDcmCallBackDidForRd0300[30] SWTST_udtDcmCallBackDidForRd0300[31] SWTST_udtDcmCallBackDidForRd0300[32] SWTST_udtDcmCallBackDidForRd0300[33] SWTST_udtDcmCallBackDidForRd0300[34] SWTST_udtDcmCallBackDidForRd0300[35] SWTST_udtDcmCallBackDidForRd0300[36] SWTST_udtDcmCallBackDidForRd0300[37] SWTST_udtDcmCallBackDidForRd0300[38] SWTST_udtDcmCallBackDidForRd0300[39] SWTST_udtDcmCallBackDidForRd0300[3] SWTST_udtDcmCallBackDidForRd0300[40] SWTST_udtDcmCallBackDidForRd0300[41] SWTST_udtDcmCallBackDidForRd0300[42] SWTST_udtDcmCallBackDidForRd0300[43] SWTST_udtDcmCallBackDidForRd0300[44] SWTST_udtDcmCallBackDidForRd0300[45] SWTST_udtDcmCallBackDidForRd0300[46] SWTST_udtDcmCallBackDidForRd0300[47] SWTST_udtDcmCallBackDidForRd0300[48] SWTST_udtDcmCallBackDidForRd0300[49] SWTST_udtDcmCallBackDidForRd0300[4] SWTST_udtDcmCallBackDidForRd0300[50] SWTST_udtDcmCallBackDidForRd0300[51] SWTST_udtDcmCallBackDidForRd0300[52] SWTST_udtDcmCallBackDidForRd0300[53] SWTST_udtDcmCallBackDidForRd0300[54] SWTST_udtDcmCallBackDidForRd0300[55] SWTST_udtDcmCallBackDidForRd0300[56] SWTST_udtDcmCallBackDidForRd0300[57] SWTST_udtDcmCallBackDidForRd0300[58] SWTST_udtDcmCallBackDidForRd0300[59] SWTST_udtDcmCallBackDidForRd0300[5] SWTST_udtDcmCallBackDidForRd0300[60] SWTST_udtDcmCallBackDidForRd0300[61] SWTST_udtDcmCallBackDidForRd0300[62] SWTST_udtDcmCallBackDidForRd0300[63] SWTST_udtDcmCallBackDidForRd0300[64] SWTST_udtDcmCallBackDidForRd0300[65] SWTST_udtDcmCallBackDidForRd0300[66] SWTST_udtDcmCallBackDidForRd0300[67] SWTST_udtDcmCallBackDidForRd0300[68] SWTST_udtDcmCallBackDidForRd0300[69] SWTST_udtDcmCallBackDidForRd0300[6] SWTST_udtDcmCallBackDidForRd0300[70] SWTST_udtDcmCallBackDidForRd0300[71] SWTST_udtDcmCallBackDidForRd0300[72] SWTST_udtDcmCallBackDidForRd0300[73] SWTST_udtDcmCallBackDidForRd0300[74] SWTST_udtDcmCallBackDidForRd0300[75] SWTST_udtDcmCallBackDidForRd0300[76] SWTST_udtDcmCallBackDidForRd0300[77] SWTST_udtDcmCallBackDidForRd0300[78] SWTST_udtDcmCallBackDidForRd0300[79] SWTST_udtDcmCallBackDidForRd0300[7] SWTST_udtDcmCallBackDidForRd0300[80] SWTST_udtDcmCallBackDidForRd0300[81] SWTST_udtDcmCallBackDidForRd0300[82] SWTST_udtDcmCallBackDidForRd0300[83] SWTST_udtDcmCallBackDidForRd0300[84] SWTST_udtDcmCallBackDidForRd0300[85] SWTST_udtDcmCallBackDidForRd0300[86] /end OUT_MEASUREMENT
/end FUNCTION
/end MODULE
/end PROJECT
