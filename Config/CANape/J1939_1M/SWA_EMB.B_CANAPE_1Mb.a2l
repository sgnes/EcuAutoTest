ASAP2_VERSION 1 70
/begin PROJECT TEST_PROJECT "TEST_PROJECT"
/begin HEADER "TEST_PROJECT" PROJECT_NO D0 VERSION "3095.02" /end HEADER
/begin MODULE TEST_PROJECT "TestSupplier"
/begin MOD_COMMON "" DEPOSIT ABSOLUTE BYTE_ORDER MSB_LAST ALIGNMENT_BYTE 1 ALIGNMENT_WORD 2 ALIGNMENT_LONG 4 ALIGNMENT_INT64 1 ALIGNMENT_FLOAT32_IEEE 4 ALIGNMENT_FLOAT64_IEEE 8 /end MOD_COMMON
/begin MEASUREMENT SWTST_u32CalibTst3[94] "SWTST_u32CalibTst3[94]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013550 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst3[95] "SWTST_u32CalibTst3[95]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013554 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst3[96] "SWTST_u32CalibTst3[96]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013558 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst3[97] "SWTST_u32CalibTst3[97]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001355C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst3[98] "SWTST_u32CalibTst3[98]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013560 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst3[99] "SWTST_u32CalibTst3[99]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013564 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst3[9] "SWTST_u32CalibTst3[9]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600133FC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4 "SWTST_u32CalibTst4" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 100 1 1 ECU_ADDRESS 0x60013248 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[0] "SWTST_u32CalibTst4[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013248 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[10] "SWTST_u32CalibTst4[10]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013270 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[11] "SWTST_u32CalibTst4[11]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013274 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[12] "SWTST_u32CalibTst4[12]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013278 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[13] "SWTST_u32CalibTst4[13]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001327C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[14] "SWTST_u32CalibTst4[14]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013280 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[15] "SWTST_u32CalibTst4[15]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013284 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[16] "SWTST_u32CalibTst4[16]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013288 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[17] "SWTST_u32CalibTst4[17]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001328C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[18] "SWTST_u32CalibTst4[18]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013290 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[19] "SWTST_u32CalibTst4[19]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013294 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[1] "SWTST_u32CalibTst4[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001324C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[20] "SWTST_u32CalibTst4[20]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013298 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[21] "SWTST_u32CalibTst4[21]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001329C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[22] "SWTST_u32CalibTst4[22]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600132A0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[23] "SWTST_u32CalibTst4[23]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600132A4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[24] "SWTST_u32CalibTst4[24]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600132A8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[25] "SWTST_u32CalibTst4[25]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600132AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[26] "SWTST_u32CalibTst4[26]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600132B0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[27] "SWTST_u32CalibTst4[27]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600132B4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[28] "SWTST_u32CalibTst4[28]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600132B8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[29] "SWTST_u32CalibTst4[29]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600132BC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[2] "SWTST_u32CalibTst4[2]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013250 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[30] "SWTST_u32CalibTst4[30]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600132C0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[31] "SWTST_u32CalibTst4[31]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600132C4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[32] "SWTST_u32CalibTst4[32]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600132C8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[33] "SWTST_u32CalibTst4[33]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600132CC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[34] "SWTST_u32CalibTst4[34]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600132D0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[35] "SWTST_u32CalibTst4[35]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600132D4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[36] "SWTST_u32CalibTst4[36]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600132D8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[37] "SWTST_u32CalibTst4[37]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600132DC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[38] "SWTST_u32CalibTst4[38]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600132E0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[39] "SWTST_u32CalibTst4[39]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600132E4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[3] "SWTST_u32CalibTst4[3]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013254 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[40] "SWTST_u32CalibTst4[40]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600132E8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[41] "SWTST_u32CalibTst4[41]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600132EC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[42] "SWTST_u32CalibTst4[42]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600132F0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[43] "SWTST_u32CalibTst4[43]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600132F4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[44] "SWTST_u32CalibTst4[44]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600132F8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[45] "SWTST_u32CalibTst4[45]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600132FC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[46] "SWTST_u32CalibTst4[46]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013300 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[47] "SWTST_u32CalibTst4[47]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013304 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[48] "SWTST_u32CalibTst4[48]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013308 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[49] "SWTST_u32CalibTst4[49]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001330C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[4] "SWTST_u32CalibTst4[4]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013258 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[50] "SWTST_u32CalibTst4[50]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013310 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[51] "SWTST_u32CalibTst4[51]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013314 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[52] "SWTST_u32CalibTst4[52]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013318 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[53] "SWTST_u32CalibTst4[53]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001331C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[54] "SWTST_u32CalibTst4[54]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013320 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[55] "SWTST_u32CalibTst4[55]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013324 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[56] "SWTST_u32CalibTst4[56]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013328 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[57] "SWTST_u32CalibTst4[57]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001332C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[58] "SWTST_u32CalibTst4[58]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013330 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[59] "SWTST_u32CalibTst4[59]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013334 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[5] "SWTST_u32CalibTst4[5]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001325C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[60] "SWTST_u32CalibTst4[60]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013338 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[61] "SWTST_u32CalibTst4[61]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001333C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[62] "SWTST_u32CalibTst4[62]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013340 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[63] "SWTST_u32CalibTst4[63]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013344 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[64] "SWTST_u32CalibTst4[64]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013348 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[65] "SWTST_u32CalibTst4[65]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001334C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[66] "SWTST_u32CalibTst4[66]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013350 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[67] "SWTST_u32CalibTst4[67]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013354 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[68] "SWTST_u32CalibTst4[68]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013358 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[69] "SWTST_u32CalibTst4[69]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001335C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[6] "SWTST_u32CalibTst4[6]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013260 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[70] "SWTST_u32CalibTst4[70]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013360 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[71] "SWTST_u32CalibTst4[71]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013364 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[72] "SWTST_u32CalibTst4[72]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013368 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[73] "SWTST_u32CalibTst4[73]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001336C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[74] "SWTST_u32CalibTst4[74]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013370 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[75] "SWTST_u32CalibTst4[75]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013374 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[76] "SWTST_u32CalibTst4[76]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013378 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[77] "SWTST_u32CalibTst4[77]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001337C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[78] "SWTST_u32CalibTst4[78]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013380 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[79] "SWTST_u32CalibTst4[79]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013384 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[7] "SWTST_u32CalibTst4[7]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013264 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[80] "SWTST_u32CalibTst4[80]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013388 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[81] "SWTST_u32CalibTst4[81]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001338C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[82] "SWTST_u32CalibTst4[82]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013390 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[83] "SWTST_u32CalibTst4[83]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013394 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[84] "SWTST_u32CalibTst4[84]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013398 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[85] "SWTST_u32CalibTst4[85]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001339C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[86] "SWTST_u32CalibTst4[86]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600133A0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[87] "SWTST_u32CalibTst4[87]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600133A4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[88] "SWTST_u32CalibTst4[88]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600133A8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[89] "SWTST_u32CalibTst4[89]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600133AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[8] "SWTST_u32CalibTst4[8]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013268 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[90] "SWTST_u32CalibTst4[90]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600133B0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[91] "SWTST_u32CalibTst4[91]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600133B4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[92] "SWTST_u32CalibTst4[92]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600133B8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[93] "SWTST_u32CalibTst4[93]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600133BC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[94] "SWTST_u32CalibTst4[94]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600133C0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[95] "SWTST_u32CalibTst4[95]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600133C4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[96] "SWTST_u32CalibTst4[96]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600133C8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[97] "SWTST_u32CalibTst4[97]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600133CC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[98] "SWTST_u32CalibTst4[98]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600133D0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[99] "SWTST_u32CalibTst4[99]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600133D4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst4[9] "SWTST_u32CalibTst4[9]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001326C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5 "SWTST_u32CalibTst5" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 100 1 1 ECU_ADDRESS 0x600130B8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[0] "SWTST_u32CalibTst5[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600130B8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[10] "SWTST_u32CalibTst5[10]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600130E0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[11] "SWTST_u32CalibTst5[11]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600130E4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[12] "SWTST_u32CalibTst5[12]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600130E8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[13] "SWTST_u32CalibTst5[13]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600130EC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[14] "SWTST_u32CalibTst5[14]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600130F0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[15] "SWTST_u32CalibTst5[15]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600130F4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[16] "SWTST_u32CalibTst5[16]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600130F8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[17] "SWTST_u32CalibTst5[17]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600130FC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[18] "SWTST_u32CalibTst5[18]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013100 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[19] "SWTST_u32CalibTst5[19]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013104 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[1] "SWTST_u32CalibTst5[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600130BC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[20] "SWTST_u32CalibTst5[20]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013108 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[21] "SWTST_u32CalibTst5[21]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001310C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[22] "SWTST_u32CalibTst5[22]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013110 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[23] "SWTST_u32CalibTst5[23]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013114 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[24] "SWTST_u32CalibTst5[24]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013118 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[25] "SWTST_u32CalibTst5[25]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001311C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[26] "SWTST_u32CalibTst5[26]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013120 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[27] "SWTST_u32CalibTst5[27]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013124 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[28] "SWTST_u32CalibTst5[28]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013128 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[29] "SWTST_u32CalibTst5[29]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001312C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[2] "SWTST_u32CalibTst5[2]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600130C0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[30] "SWTST_u32CalibTst5[30]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013130 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[31] "SWTST_u32CalibTst5[31]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013134 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[32] "SWTST_u32CalibTst5[32]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013138 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[33] "SWTST_u32CalibTst5[33]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001313C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[34] "SWTST_u32CalibTst5[34]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013140 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[35] "SWTST_u32CalibTst5[35]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013144 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[36] "SWTST_u32CalibTst5[36]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013148 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[37] "SWTST_u32CalibTst5[37]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001314C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[38] "SWTST_u32CalibTst5[38]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013150 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[39] "SWTST_u32CalibTst5[39]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013154 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[3] "SWTST_u32CalibTst5[3]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600130C4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[40] "SWTST_u32CalibTst5[40]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013158 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[41] "SWTST_u32CalibTst5[41]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001315C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[42] "SWTST_u32CalibTst5[42]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013160 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[43] "SWTST_u32CalibTst5[43]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013164 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[44] "SWTST_u32CalibTst5[44]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013168 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[45] "SWTST_u32CalibTst5[45]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001316C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[46] "SWTST_u32CalibTst5[46]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013170 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[47] "SWTST_u32CalibTst5[47]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013174 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[48] "SWTST_u32CalibTst5[48]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013178 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[49] "SWTST_u32CalibTst5[49]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001317C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[4] "SWTST_u32CalibTst5[4]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600130C8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[50] "SWTST_u32CalibTst5[50]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013180 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[51] "SWTST_u32CalibTst5[51]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013184 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[52] "SWTST_u32CalibTst5[52]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013188 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[53] "SWTST_u32CalibTst5[53]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001318C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[54] "SWTST_u32CalibTst5[54]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013190 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[55] "SWTST_u32CalibTst5[55]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013194 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[56] "SWTST_u32CalibTst5[56]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013198 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[57] "SWTST_u32CalibTst5[57]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001319C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[58] "SWTST_u32CalibTst5[58]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600131A0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[59] "SWTST_u32CalibTst5[59]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600131A4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[5] "SWTST_u32CalibTst5[5]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600130CC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[60] "SWTST_u32CalibTst5[60]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600131A8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[61] "SWTST_u32CalibTst5[61]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600131AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[62] "SWTST_u32CalibTst5[62]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600131B0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[63] "SWTST_u32CalibTst5[63]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600131B4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[64] "SWTST_u32CalibTst5[64]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600131B8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[65] "SWTST_u32CalibTst5[65]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600131BC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[66] "SWTST_u32CalibTst5[66]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600131C0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[67] "SWTST_u32CalibTst5[67]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600131C4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[68] "SWTST_u32CalibTst5[68]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600131C8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[69] "SWTST_u32CalibTst5[69]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600131CC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[6] "SWTST_u32CalibTst5[6]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600130D0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[70] "SWTST_u32CalibTst5[70]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600131D0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[71] "SWTST_u32CalibTst5[71]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600131D4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[72] "SWTST_u32CalibTst5[72]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600131D8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[73] "SWTST_u32CalibTst5[73]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600131DC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[74] "SWTST_u32CalibTst5[74]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600131E0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[75] "SWTST_u32CalibTst5[75]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600131E4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[76] "SWTST_u32CalibTst5[76]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600131E8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[77] "SWTST_u32CalibTst5[77]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600131EC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[78] "SWTST_u32CalibTst5[78]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600131F0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[79] "SWTST_u32CalibTst5[79]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600131F4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[7] "SWTST_u32CalibTst5[7]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600130D4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[80] "SWTST_u32CalibTst5[80]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600131F8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[81] "SWTST_u32CalibTst5[81]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600131FC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[82] "SWTST_u32CalibTst5[82]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013200 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[83] "SWTST_u32CalibTst5[83]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013204 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[84] "SWTST_u32CalibTst5[84]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013208 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[85] "SWTST_u32CalibTst5[85]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001320C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[86] "SWTST_u32CalibTst5[86]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013210 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[87] "SWTST_u32CalibTst5[87]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013214 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[88] "SWTST_u32CalibTst5[88]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013218 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[89] "SWTST_u32CalibTst5[89]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001321C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[8] "SWTST_u32CalibTst5[8]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600130D8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[90] "SWTST_u32CalibTst5[90]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013220 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[91] "SWTST_u32CalibTst5[91]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013224 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[92] "SWTST_u32CalibTst5[92]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013228 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[93] "SWTST_u32CalibTst5[93]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001322C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[94] "SWTST_u32CalibTst5[94]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013230 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[95] "SWTST_u32CalibTst5[95]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013234 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[96] "SWTST_u32CalibTst5[96]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013238 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[97] "SWTST_u32CalibTst5[97]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001323C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[98] "SWTST_u32CalibTst5[98]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013240 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[99] "SWTST_u32CalibTst5[99]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013244 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst5[9] "SWTST_u32CalibTst5[9]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600130DC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6 "SWTST_u32CalibTst6" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 100 1 1 ECU_ADDRESS 0x60012F28 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[0] "SWTST_u32CalibTst6[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F28 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[10] "SWTST_u32CalibTst6[10]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F50 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[11] "SWTST_u32CalibTst6[11]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F54 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[12] "SWTST_u32CalibTst6[12]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F58 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[13] "SWTST_u32CalibTst6[13]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F5C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[14] "SWTST_u32CalibTst6[14]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F60 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[15] "SWTST_u32CalibTst6[15]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F64 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[16] "SWTST_u32CalibTst6[16]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F68 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[17] "SWTST_u32CalibTst6[17]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F6C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[18] "SWTST_u32CalibTst6[18]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F70 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[19] "SWTST_u32CalibTst6[19]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F74 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[1] "SWTST_u32CalibTst6[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F2C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[20] "SWTST_u32CalibTst6[20]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F78 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[21] "SWTST_u32CalibTst6[21]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F7C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[22] "SWTST_u32CalibTst6[22]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F80 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[23] "SWTST_u32CalibTst6[23]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F84 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[24] "SWTST_u32CalibTst6[24]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F88 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[25] "SWTST_u32CalibTst6[25]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F8C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[26] "SWTST_u32CalibTst6[26]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F90 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[27] "SWTST_u32CalibTst6[27]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F94 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[28] "SWTST_u32CalibTst6[28]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F98 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[29] "SWTST_u32CalibTst6[29]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F9C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[2] "SWTST_u32CalibTst6[2]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F30 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[30] "SWTST_u32CalibTst6[30]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012FA0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[31] "SWTST_u32CalibTst6[31]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012FA4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[32] "SWTST_u32CalibTst6[32]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012FA8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[33] "SWTST_u32CalibTst6[33]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012FAC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[34] "SWTST_u32CalibTst6[34]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012FB0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[35] "SWTST_u32CalibTst6[35]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012FB4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[36] "SWTST_u32CalibTst6[36]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012FB8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[37] "SWTST_u32CalibTst6[37]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012FBC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[38] "SWTST_u32CalibTst6[38]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012FC0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[39] "SWTST_u32CalibTst6[39]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012FC4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[3] "SWTST_u32CalibTst6[3]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F34 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[40] "SWTST_u32CalibTst6[40]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012FC8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[41] "SWTST_u32CalibTst6[41]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012FCC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[42] "SWTST_u32CalibTst6[42]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012FD0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[43] "SWTST_u32CalibTst6[43]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012FD4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[44] "SWTST_u32CalibTst6[44]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012FD8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[45] "SWTST_u32CalibTst6[45]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012FDC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[46] "SWTST_u32CalibTst6[46]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012FE0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[47] "SWTST_u32CalibTst6[47]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012FE4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[48] "SWTST_u32CalibTst6[48]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012FE8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[49] "SWTST_u32CalibTst6[49]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012FEC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[4] "SWTST_u32CalibTst6[4]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F38 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[50] "SWTST_u32CalibTst6[50]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012FF0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[51] "SWTST_u32CalibTst6[51]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012FF4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[52] "SWTST_u32CalibTst6[52]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012FF8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[53] "SWTST_u32CalibTst6[53]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012FFC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[54] "SWTST_u32CalibTst6[54]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013000 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[55] "SWTST_u32CalibTst6[55]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013004 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[56] "SWTST_u32CalibTst6[56]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013008 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[57] "SWTST_u32CalibTst6[57]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001300C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[58] "SWTST_u32CalibTst6[58]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013010 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[59] "SWTST_u32CalibTst6[59]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013014 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[5] "SWTST_u32CalibTst6[5]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F3C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[60] "SWTST_u32CalibTst6[60]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013018 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[61] "SWTST_u32CalibTst6[61]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001301C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[62] "SWTST_u32CalibTst6[62]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013020 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[63] "SWTST_u32CalibTst6[63]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013024 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[64] "SWTST_u32CalibTst6[64]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013028 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[65] "SWTST_u32CalibTst6[65]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001302C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[66] "SWTST_u32CalibTst6[66]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013030 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[67] "SWTST_u32CalibTst6[67]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013034 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[68] "SWTST_u32CalibTst6[68]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013038 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[69] "SWTST_u32CalibTst6[69]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001303C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[6] "SWTST_u32CalibTst6[6]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F40 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[70] "SWTST_u32CalibTst6[70]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013040 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[71] "SWTST_u32CalibTst6[71]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013044 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[72] "SWTST_u32CalibTst6[72]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013048 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[73] "SWTST_u32CalibTst6[73]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001304C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[74] "SWTST_u32CalibTst6[74]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013050 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[75] "SWTST_u32CalibTst6[75]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013054 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[76] "SWTST_u32CalibTst6[76]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013058 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[77] "SWTST_u32CalibTst6[77]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001305C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[78] "SWTST_u32CalibTst6[78]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013060 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[79] "SWTST_u32CalibTst6[79]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013064 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[7] "SWTST_u32CalibTst6[7]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F44 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[80] "SWTST_u32CalibTst6[80]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013068 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[81] "SWTST_u32CalibTst6[81]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001306C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[82] "SWTST_u32CalibTst6[82]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013070 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[83] "SWTST_u32CalibTst6[83]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013074 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[84] "SWTST_u32CalibTst6[84]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013078 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[85] "SWTST_u32CalibTst6[85]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001307C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[86] "SWTST_u32CalibTst6[86]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013080 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[87] "SWTST_u32CalibTst6[87]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013084 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[88] "SWTST_u32CalibTst6[88]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013088 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[89] "SWTST_u32CalibTst6[89]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001308C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[8] "SWTST_u32CalibTst6[8]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F48 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[90] "SWTST_u32CalibTst6[90]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013090 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[91] "SWTST_u32CalibTst6[91]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013094 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[92] "SWTST_u32CalibTst6[92]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60013098 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[93] "SWTST_u32CalibTst6[93]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001309C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[94] "SWTST_u32CalibTst6[94]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600130A0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[95] "SWTST_u32CalibTst6[95]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600130A4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[96] "SWTST_u32CalibTst6[96]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600130A8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[97] "SWTST_u32CalibTst6[97]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600130AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[98] "SWTST_u32CalibTst6[98]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600130B0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[99] "SWTST_u32CalibTst6[99]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600130B4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst6[9] "SWTST_u32CalibTst6[9]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F4C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7 "SWTST_u32CalibTst7" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 100 1 1 ECU_ADDRESS 0x60012D98 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[0] "SWTST_u32CalibTst7[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D98 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[10] "SWTST_u32CalibTst7[10]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012DC0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[11] "SWTST_u32CalibTst7[11]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012DC4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[12] "SWTST_u32CalibTst7[12]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012DC8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[13] "SWTST_u32CalibTst7[13]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012DCC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[14] "SWTST_u32CalibTst7[14]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012DD0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[15] "SWTST_u32CalibTst7[15]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012DD4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[16] "SWTST_u32CalibTst7[16]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012DD8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[17] "SWTST_u32CalibTst7[17]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012DDC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[18] "SWTST_u32CalibTst7[18]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012DE0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[19] "SWTST_u32CalibTst7[19]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012DE4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[1] "SWTST_u32CalibTst7[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D9C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[20] "SWTST_u32CalibTst7[20]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012DE8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[21] "SWTST_u32CalibTst7[21]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012DEC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[22] "SWTST_u32CalibTst7[22]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012DF0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[23] "SWTST_u32CalibTst7[23]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012DF4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[24] "SWTST_u32CalibTst7[24]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012DF8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[25] "SWTST_u32CalibTst7[25]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012DFC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[26] "SWTST_u32CalibTst7[26]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E00 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[27] "SWTST_u32CalibTst7[27]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E04 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[28] "SWTST_u32CalibTst7[28]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E08 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[29] "SWTST_u32CalibTst7[29]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E0C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[2] "SWTST_u32CalibTst7[2]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012DA0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[30] "SWTST_u32CalibTst7[30]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E10 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[31] "SWTST_u32CalibTst7[31]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E14 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[32] "SWTST_u32CalibTst7[32]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E18 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[33] "SWTST_u32CalibTst7[33]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E1C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[34] "SWTST_u32CalibTst7[34]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E20 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[35] "SWTST_u32CalibTst7[35]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E24 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[36] "SWTST_u32CalibTst7[36]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E28 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[37] "SWTST_u32CalibTst7[37]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E2C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[38] "SWTST_u32CalibTst7[38]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E30 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[39] "SWTST_u32CalibTst7[39]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E34 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[3] "SWTST_u32CalibTst7[3]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012DA4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[40] "SWTST_u32CalibTst7[40]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E38 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[41] "SWTST_u32CalibTst7[41]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E3C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[42] "SWTST_u32CalibTst7[42]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E40 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[43] "SWTST_u32CalibTst7[43]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E44 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[44] "SWTST_u32CalibTst7[44]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E48 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[45] "SWTST_u32CalibTst7[45]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E4C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[46] "SWTST_u32CalibTst7[46]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E50 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[47] "SWTST_u32CalibTst7[47]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E54 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[48] "SWTST_u32CalibTst7[48]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E58 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[49] "SWTST_u32CalibTst7[49]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E5C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[4] "SWTST_u32CalibTst7[4]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012DA8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[50] "SWTST_u32CalibTst7[50]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E60 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[51] "SWTST_u32CalibTst7[51]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E64 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[52] "SWTST_u32CalibTst7[52]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E68 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[53] "SWTST_u32CalibTst7[53]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E6C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[54] "SWTST_u32CalibTst7[54]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E70 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[55] "SWTST_u32CalibTst7[55]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E74 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[56] "SWTST_u32CalibTst7[56]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E78 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[57] "SWTST_u32CalibTst7[57]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E7C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[58] "SWTST_u32CalibTst7[58]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E80 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[59] "SWTST_u32CalibTst7[59]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E84 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[5] "SWTST_u32CalibTst7[5]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012DAC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[60] "SWTST_u32CalibTst7[60]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E88 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[61] "SWTST_u32CalibTst7[61]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E8C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[62] "SWTST_u32CalibTst7[62]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E90 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[63] "SWTST_u32CalibTst7[63]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E94 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[64] "SWTST_u32CalibTst7[64]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E98 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[65] "SWTST_u32CalibTst7[65]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012E9C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[66] "SWTST_u32CalibTst7[66]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012EA0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[67] "SWTST_u32CalibTst7[67]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012EA4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[68] "SWTST_u32CalibTst7[68]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012EA8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[69] "SWTST_u32CalibTst7[69]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012EAC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[6] "SWTST_u32CalibTst7[6]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012DB0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[70] "SWTST_u32CalibTst7[70]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012EB0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[71] "SWTST_u32CalibTst7[71]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012EB4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[72] "SWTST_u32CalibTst7[72]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012EB8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[73] "SWTST_u32CalibTst7[73]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012EBC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[74] "SWTST_u32CalibTst7[74]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012EC0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[75] "SWTST_u32CalibTst7[75]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012EC4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[76] "SWTST_u32CalibTst7[76]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012EC8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[77] "SWTST_u32CalibTst7[77]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012ECC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[78] "SWTST_u32CalibTst7[78]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012ED0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[79] "SWTST_u32CalibTst7[79]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012ED4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[7] "SWTST_u32CalibTst7[7]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012DB4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[80] "SWTST_u32CalibTst7[80]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012ED8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[81] "SWTST_u32CalibTst7[81]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012EDC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[82] "SWTST_u32CalibTst7[82]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012EE0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[83] "SWTST_u32CalibTst7[83]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012EE4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[84] "SWTST_u32CalibTst7[84]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012EE8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[85] "SWTST_u32CalibTst7[85]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012EEC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[86] "SWTST_u32CalibTst7[86]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012EF0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[87] "SWTST_u32CalibTst7[87]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012EF4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[88] "SWTST_u32CalibTst7[88]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012EF8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[89] "SWTST_u32CalibTst7[89]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012EFC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[8] "SWTST_u32CalibTst7[8]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012DB8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[90] "SWTST_u32CalibTst7[90]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F00 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[91] "SWTST_u32CalibTst7[91]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F04 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[92] "SWTST_u32CalibTst7[92]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F08 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[93] "SWTST_u32CalibTst7[93]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F0C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[94] "SWTST_u32CalibTst7[94]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F10 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[95] "SWTST_u32CalibTst7[95]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F14 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[96] "SWTST_u32CalibTst7[96]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F18 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[97] "SWTST_u32CalibTst7[97]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F1C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[98] "SWTST_u32CalibTst7[98]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F20 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[99] "SWTST_u32CalibTst7[99]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012F24 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst7[9] "SWTST_u32CalibTst7[9]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012DBC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8 "SWTST_u32CalibTst8" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 100 1 1 ECU_ADDRESS 0x60012C08 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[0] "SWTST_u32CalibTst8[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C08 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[10] "SWTST_u32CalibTst8[10]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C30 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[11] "SWTST_u32CalibTst8[11]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C34 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[12] "SWTST_u32CalibTst8[12]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C38 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[13] "SWTST_u32CalibTst8[13]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C3C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[14] "SWTST_u32CalibTst8[14]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C40 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[15] "SWTST_u32CalibTst8[15]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C44 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[16] "SWTST_u32CalibTst8[16]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C48 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[17] "SWTST_u32CalibTst8[17]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C4C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[18] "SWTST_u32CalibTst8[18]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C50 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[19] "SWTST_u32CalibTst8[19]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C54 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[1] "SWTST_u32CalibTst8[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C0C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[20] "SWTST_u32CalibTst8[20]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C58 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[21] "SWTST_u32CalibTst8[21]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C5C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[22] "SWTST_u32CalibTst8[22]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C60 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[23] "SWTST_u32CalibTst8[23]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C64 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[24] "SWTST_u32CalibTst8[24]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C68 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[25] "SWTST_u32CalibTst8[25]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C6C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[26] "SWTST_u32CalibTst8[26]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C70 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[27] "SWTST_u32CalibTst8[27]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C74 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[28] "SWTST_u32CalibTst8[28]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C78 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[29] "SWTST_u32CalibTst8[29]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C7C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[2] "SWTST_u32CalibTst8[2]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C10 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[30] "SWTST_u32CalibTst8[30]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C80 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[31] "SWTST_u32CalibTst8[31]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C84 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[32] "SWTST_u32CalibTst8[32]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C88 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[33] "SWTST_u32CalibTst8[33]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C8C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[34] "SWTST_u32CalibTst8[34]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C90 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[35] "SWTST_u32CalibTst8[35]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C94 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[36] "SWTST_u32CalibTst8[36]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C98 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[37] "SWTST_u32CalibTst8[37]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C9C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[38] "SWTST_u32CalibTst8[38]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012CA0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[39] "SWTST_u32CalibTst8[39]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012CA4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[3] "SWTST_u32CalibTst8[3]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C14 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[40] "SWTST_u32CalibTst8[40]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012CA8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[41] "SWTST_u32CalibTst8[41]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012CAC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[42] "SWTST_u32CalibTst8[42]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012CB0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[43] "SWTST_u32CalibTst8[43]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012CB4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[44] "SWTST_u32CalibTst8[44]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012CB8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[45] "SWTST_u32CalibTst8[45]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012CBC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[46] "SWTST_u32CalibTst8[46]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012CC0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[47] "SWTST_u32CalibTst8[47]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012CC4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[48] "SWTST_u32CalibTst8[48]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012CC8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[49] "SWTST_u32CalibTst8[49]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012CCC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[4] "SWTST_u32CalibTst8[4]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C18 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[50] "SWTST_u32CalibTst8[50]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012CD0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[51] "SWTST_u32CalibTst8[51]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012CD4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[52] "SWTST_u32CalibTst8[52]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012CD8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[53] "SWTST_u32CalibTst8[53]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012CDC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[54] "SWTST_u32CalibTst8[54]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012CE0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[55] "SWTST_u32CalibTst8[55]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012CE4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[56] "SWTST_u32CalibTst8[56]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012CE8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[57] "SWTST_u32CalibTst8[57]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012CEC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[58] "SWTST_u32CalibTst8[58]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012CF0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[59] "SWTST_u32CalibTst8[59]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012CF4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[5] "SWTST_u32CalibTst8[5]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C1C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[60] "SWTST_u32CalibTst8[60]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012CF8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[61] "SWTST_u32CalibTst8[61]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012CFC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[62] "SWTST_u32CalibTst8[62]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D00 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[63] "SWTST_u32CalibTst8[63]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D04 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[64] "SWTST_u32CalibTst8[64]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D08 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[65] "SWTST_u32CalibTst8[65]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D0C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[66] "SWTST_u32CalibTst8[66]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D10 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[67] "SWTST_u32CalibTst8[67]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D14 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[68] "SWTST_u32CalibTst8[68]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D18 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[69] "SWTST_u32CalibTst8[69]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D1C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[6] "SWTST_u32CalibTst8[6]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C20 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[70] "SWTST_u32CalibTst8[70]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D20 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[71] "SWTST_u32CalibTst8[71]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D24 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[72] "SWTST_u32CalibTst8[72]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D28 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[73] "SWTST_u32CalibTst8[73]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D2C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[74] "SWTST_u32CalibTst8[74]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D30 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[75] "SWTST_u32CalibTst8[75]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D34 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[76] "SWTST_u32CalibTst8[76]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D38 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[77] "SWTST_u32CalibTst8[77]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D3C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[78] "SWTST_u32CalibTst8[78]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D40 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[79] "SWTST_u32CalibTst8[79]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D44 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[7] "SWTST_u32CalibTst8[7]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C24 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[80] "SWTST_u32CalibTst8[80]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D48 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[81] "SWTST_u32CalibTst8[81]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D4C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[82] "SWTST_u32CalibTst8[82]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D50 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[83] "SWTST_u32CalibTst8[83]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D54 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[84] "SWTST_u32CalibTst8[84]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D58 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[85] "SWTST_u32CalibTst8[85]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D5C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[86] "SWTST_u32CalibTst8[86]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D60 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[87] "SWTST_u32CalibTst8[87]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D64 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[88] "SWTST_u32CalibTst8[88]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D68 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[89] "SWTST_u32CalibTst8[89]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D6C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[8] "SWTST_u32CalibTst8[8]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C28 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[90] "SWTST_u32CalibTst8[90]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D70 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[91] "SWTST_u32CalibTst8[91]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D74 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[92] "SWTST_u32CalibTst8[92]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D78 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[93] "SWTST_u32CalibTst8[93]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D7C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[94] "SWTST_u32CalibTst8[94]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D80 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[95] "SWTST_u32CalibTst8[95]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D84 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[96] "SWTST_u32CalibTst8[96]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D88 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[97] "SWTST_u32CalibTst8[97]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D8C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[98] "SWTST_u32CalibTst8[98]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D90 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[99] "SWTST_u32CalibTst8[99]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012D94 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst8[9] "SWTST_u32CalibTst8[9]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C2C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9 "SWTST_u32CalibTst9" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 100 1 1 ECU_ADDRESS 0x60012A78 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[0] "SWTST_u32CalibTst9[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A78 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[10] "SWTST_u32CalibTst9[10]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012AA0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[11] "SWTST_u32CalibTst9[11]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012AA4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[12] "SWTST_u32CalibTst9[12]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012AA8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[13] "SWTST_u32CalibTst9[13]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012AAC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[14] "SWTST_u32CalibTst9[14]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012AB0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[15] "SWTST_u32CalibTst9[15]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012AB4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[16] "SWTST_u32CalibTst9[16]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012AB8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[17] "SWTST_u32CalibTst9[17]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012ABC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[18] "SWTST_u32CalibTst9[18]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012AC0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[19] "SWTST_u32CalibTst9[19]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012AC4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[1] "SWTST_u32CalibTst9[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A7C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[20] "SWTST_u32CalibTst9[20]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012AC8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[21] "SWTST_u32CalibTst9[21]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012ACC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[22] "SWTST_u32CalibTst9[22]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012AD0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[23] "SWTST_u32CalibTst9[23]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012AD4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[24] "SWTST_u32CalibTst9[24]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012AD8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[25] "SWTST_u32CalibTst9[25]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012ADC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[26] "SWTST_u32CalibTst9[26]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012AE0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[27] "SWTST_u32CalibTst9[27]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012AE4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[28] "SWTST_u32CalibTst9[28]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012AE8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[29] "SWTST_u32CalibTst9[29]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012AEC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[2] "SWTST_u32CalibTst9[2]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A80 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[30] "SWTST_u32CalibTst9[30]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012AF0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[31] "SWTST_u32CalibTst9[31]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012AF4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[32] "SWTST_u32CalibTst9[32]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012AF8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[33] "SWTST_u32CalibTst9[33]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012AFC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[34] "SWTST_u32CalibTst9[34]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B00 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[35] "SWTST_u32CalibTst9[35]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B04 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[36] "SWTST_u32CalibTst9[36]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B08 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[37] "SWTST_u32CalibTst9[37]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B0C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[38] "SWTST_u32CalibTst9[38]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B10 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[39] "SWTST_u32CalibTst9[39]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B14 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[3] "SWTST_u32CalibTst9[3]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A84 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[40] "SWTST_u32CalibTst9[40]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B18 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[41] "SWTST_u32CalibTst9[41]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B1C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[42] "SWTST_u32CalibTst9[42]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B20 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[43] "SWTST_u32CalibTst9[43]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B24 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[44] "SWTST_u32CalibTst9[44]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B28 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[45] "SWTST_u32CalibTst9[45]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B2C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[46] "SWTST_u32CalibTst9[46]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B30 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[47] "SWTST_u32CalibTst9[47]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B34 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[48] "SWTST_u32CalibTst9[48]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B38 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[49] "SWTST_u32CalibTst9[49]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B3C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[4] "SWTST_u32CalibTst9[4]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A88 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[50] "SWTST_u32CalibTst9[50]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B40 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[51] "SWTST_u32CalibTst9[51]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B44 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[52] "SWTST_u32CalibTst9[52]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B48 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[53] "SWTST_u32CalibTst9[53]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B4C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[54] "SWTST_u32CalibTst9[54]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B50 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[55] "SWTST_u32CalibTst9[55]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B54 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[56] "SWTST_u32CalibTst9[56]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B58 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[57] "SWTST_u32CalibTst9[57]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B5C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[58] "SWTST_u32CalibTst9[58]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B60 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[59] "SWTST_u32CalibTst9[59]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B64 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[5] "SWTST_u32CalibTst9[5]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A8C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[60] "SWTST_u32CalibTst9[60]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B68 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[61] "SWTST_u32CalibTst9[61]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B6C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[62] "SWTST_u32CalibTst9[62]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B70 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[63] "SWTST_u32CalibTst9[63]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B74 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[64] "SWTST_u32CalibTst9[64]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B78 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[65] "SWTST_u32CalibTst9[65]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B7C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[66] "SWTST_u32CalibTst9[66]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B80 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[67] "SWTST_u32CalibTst9[67]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B84 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[68] "SWTST_u32CalibTst9[68]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B88 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[69] "SWTST_u32CalibTst9[69]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B8C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[6] "SWTST_u32CalibTst9[6]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A90 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[70] "SWTST_u32CalibTst9[70]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B90 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[71] "SWTST_u32CalibTst9[71]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B94 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[72] "SWTST_u32CalibTst9[72]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B98 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[73] "SWTST_u32CalibTst9[73]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012B9C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[74] "SWTST_u32CalibTst9[74]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012BA0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[75] "SWTST_u32CalibTst9[75]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012BA4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[76] "SWTST_u32CalibTst9[76]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012BA8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[77] "SWTST_u32CalibTst9[77]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012BAC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[78] "SWTST_u32CalibTst9[78]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012BB0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[79] "SWTST_u32CalibTst9[79]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012BB4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[7] "SWTST_u32CalibTst9[7]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A94 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[80] "SWTST_u32CalibTst9[80]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012BB8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[81] "SWTST_u32CalibTst9[81]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012BBC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[82] "SWTST_u32CalibTst9[82]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012BC0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[83] "SWTST_u32CalibTst9[83]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012BC4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[84] "SWTST_u32CalibTst9[84]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012BC8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[85] "SWTST_u32CalibTst9[85]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012BCC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[86] "SWTST_u32CalibTst9[86]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012BD0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[87] "SWTST_u32CalibTst9[87]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012BD4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[88] "SWTST_u32CalibTst9[88]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012BD8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[89] "SWTST_u32CalibTst9[89]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012BDC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[8] "SWTST_u32CalibTst9[8]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A98 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[90] "SWTST_u32CalibTst9[90]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012BE0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[91] "SWTST_u32CalibTst9[91]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012BE4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[92] "SWTST_u32CalibTst9[92]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012BE8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[93] "SWTST_u32CalibTst9[93]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012BEC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[94] "SWTST_u32CalibTst9[94]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012BF0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[95] "SWTST_u32CalibTst9[95]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012BF4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[96] "SWTST_u32CalibTst9[96]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012BF8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[97] "SWTST_u32CalibTst9[97]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012BFC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[98] "SWTST_u32CalibTst9[98]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C00 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[99] "SWTST_u32CalibTst9[99]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012C04 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst9[9] "SWTST_u32CalibTst9[9]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A9C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32ComTstErrInfo "Information on the error that stopped the sequence" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A74 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32DioTstErrInfo "Information on the error that stopped the sequence" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A70 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32EVPTstErrInfo "Information on the error that stopped the sequence" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A6C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32Lvl2RamCrcTstInitGlbLvl2TstVar "hex value" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A68 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32Lvl2RamCrcTstLvl2GlbVar "SWTST_u32Lvl2RamCrcTstLvl2GlbVar" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A64 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32Lvl2RamCrcTstPwrOnClrGlbLvl2TstVar "SWTST_u32Lvl2RamCrcTstPwrOnClrGlbLvl2TstVar" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A60 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32Lvl2RamCrcTstPwrOnInitGlbLvl2TstVar "hex value" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A5C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32SftyPreSafeStsCntr "Safety error counter" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A58 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32Tle62X0TstErrInfo "Information on the error that stopped the sequence" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012A54 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8AdcResumeTstNr "SWTST_u8AdcResumeTstNr" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012515 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8AdcTstDoneNr "SWTST_u8AdcTstDoneNr" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012514 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8AdcTstErrId "SWTST_u8AdcTstErrId" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012513 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8AdcTstNrNm1 "SWTST_u8AdcTstNrNm1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012512 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Btt6020ResumeTstNr "SWTST_u8Btt6020ResumeTstNr" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012511 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Btt6020TstDoneNr "Last test done" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012510 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Btt6020TstErrId "Identifier of the first error in the test sequence" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001250F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8Btt6020TstNrNm1 "'Previous value of ''SWTST_ku8Btt6020TstNrC'''" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001250E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8CalibResumeTstNr "SWTST_u8CalibResumeTstNr" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001250D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8CalibTstDoneNr "Last test done" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001250C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8CalibTstErrId "Identifier of the first error in the test sequence" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001250B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8CalibTstNrNm1 "'Previous value of ''SWTST_ku8CalibTstNrC'''" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001250A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa00BrakeSwitch "SWTST_u8ComRdCcvs1Sa00BrakeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012509 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa00ClutchSwitch "SWTST_u8ComRdCcvs1Sa00ClutchSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012508 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa00CruiseCtrlAccelerateSwitch "SWTST_u8ComRdCcvs1Sa00CruiseCtrlAccelerateSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012507 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa00CruiseCtrlActive "SWTST_u8ComRdCcvs1Sa00CruiseCtrlActive" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012506 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa00CruiseCtrlCoastSwitch "SWTST_u8ComRdCcvs1Sa00CruiseCtrlCoastSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012505 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa00CruiseCtrlEnableSwitch "SWTST_u8ComRdCcvs1Sa00CruiseCtrlEnableSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012504 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa00CruiseCtrlPauseSwitch "SWTST_u8ComRdCcvs1Sa00CruiseCtrlPauseSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012503 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa00CruiseCtrlResumeSwitch "SWTST_u8ComRdCcvs1Sa00CruiseCtrlResumeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012502 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa00CruiseCtrlSetSwitch "SWTST_u8ComRdCcvs1Sa00CruiseCtrlSetSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012501 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa00CruiseCtrlStates "SWTST_u8ComRdCcvs1Sa00CruiseCtrlStates" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012500 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa00EngIdleDecrementSwitch "SWTST_u8ComRdCcvs1Sa00EngIdleDecrementSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124FF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa00EngIdleIncrementSwitch "SWTST_u8ComRdCcvs1Sa00EngIdleIncrementSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124FE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa00EngShutdownOverrideSwitch "SWTST_u8ComRdCcvs1Sa00EngShutdownOverrideSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124FD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa00EngTestModeSwitch "SWTST_u8ComRdCcvs1Sa00EngTestModeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124FC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa00PTOGovernorState "SWTST_u8ComRdCcvs1Sa00PTOGovernorState" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124F9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa00ParkBrakeReleaseInhibitRq "SWTST_u8ComRdCcvs1Sa00ParkBrakeReleaseInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124FB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa00ParkingBrakeSwitch "SWTST_u8ComRdCcvs1Sa00ParkingBrakeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124FA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa00TwoSpeedAxleSwitch "SWTST_u8ComRdCcvs1Sa00TwoSpeedAxleSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124F8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa17BrakeSwitch "SWTST_u8ComRdCcvs1Sa17BrakeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124F7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa17ClutchSwitch "SWTST_u8ComRdCcvs1Sa17ClutchSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124F6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa17CruiseCtrlAccelerateSwitch "SWTST_u8ComRdCcvs1Sa17CruiseCtrlAccelerateSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124F5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa17CruiseCtrlActive "SWTST_u8ComRdCcvs1Sa17CruiseCtrlActive" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124F4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa17CruiseCtrlCoastSwitch "SWTST_u8ComRdCcvs1Sa17CruiseCtrlCoastSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124F3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa17CruiseCtrlEnableSwitch "SWTST_u8ComRdCcvs1Sa17CruiseCtrlEnableSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124F2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa17CruiseCtrlPauseSwitch "SWTST_u8ComRdCcvs1Sa17CruiseCtrlPauseSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124F1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa17CruiseCtrlResumeSwitch "SWTST_u8ComRdCcvs1Sa17CruiseCtrlResumeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124F0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa17CruiseCtrlSetSwitch "SWTST_u8ComRdCcvs1Sa17CruiseCtrlSetSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124EF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa17CruiseCtrlStates "SWTST_u8ComRdCcvs1Sa17CruiseCtrlStates" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124EE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa17EngIdleDecrementSwitch "SWTST_u8ComRdCcvs1Sa17EngIdleDecrementSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124ED READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa17EngIdleIncrementSwitch "SWTST_u8ComRdCcvs1Sa17EngIdleIncrementSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124EC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa17EngShutdownOverrideSwitch "SWTST_u8ComRdCcvs1Sa17EngShutdownOverrideSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124EB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa17EngTestModeSwitch "SWTST_u8ComRdCcvs1Sa17EngTestModeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124EA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa17PTOGovernorState "SWTST_u8ComRdCcvs1Sa17PTOGovernorState" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124E7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa17ParkBrakeReleaseInhibitRq "SWTST_u8ComRdCcvs1Sa17ParkBrakeReleaseInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124E9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa17ParkingBrakeSwitch "SWTST_u8ComRdCcvs1Sa17ParkingBrakeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124E8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa17TwoSpeedAxleSwitch "SWTST_u8ComRdCcvs1Sa17TwoSpeedAxleSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124E6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa232BrakeSwitch "SWTST_u8ComRdCcvs1Sa232BrakeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124E5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa232ClutchSwitch "SWTST_u8ComRdCcvs1Sa232ClutchSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124E4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa232CruiseCtrlAccelerateSwitch "SWTST_u8ComRdCcvs1Sa232CruiseCtrlAccelerateSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124E3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa232CruiseCtrlActive "SWTST_u8ComRdCcvs1Sa232CruiseCtrlActive" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124E2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa232CruiseCtrlCoastSwitch "SWTST_u8ComRdCcvs1Sa232CruiseCtrlCoastSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124E1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa232CruiseCtrlEnableSwitch "SWTST_u8ComRdCcvs1Sa232CruiseCtrlEnableSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124E0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa232CruiseCtrlPauseSwitch "SWTST_u8ComRdCcvs1Sa232CruiseCtrlPauseSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124DF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa232CruiseCtrlResumeSwitch "SWTST_u8ComRdCcvs1Sa232CruiseCtrlResumeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124DE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa232CruiseCtrlSetSwitch "SWTST_u8ComRdCcvs1Sa232CruiseCtrlSetSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124DD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa232CruiseCtrlStates "SWTST_u8ComRdCcvs1Sa232CruiseCtrlStates" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124DC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa232EngIdleDecrementSwitch "SWTST_u8ComRdCcvs1Sa232EngIdleDecrementSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124DB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa232EngIdleIncrementSwitch "SWTST_u8ComRdCcvs1Sa232EngIdleIncrementSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124DA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa232EngShutdownOverrideSwitch "SWTST_u8ComRdCcvs1Sa232EngShutdownOverrideSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124D9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa232EngTestModeSwitch "SWTST_u8ComRdCcvs1Sa232EngTestModeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124D8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa232PTOGovernorState "SWTST_u8ComRdCcvs1Sa232PTOGovernorState" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124D5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa232ParkBrakeReleaseInhibitRq "SWTST_u8ComRdCcvs1Sa232ParkBrakeReleaseInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124D7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa232ParkingBrakeSwitch "SWTST_u8ComRdCcvs1Sa232ParkingBrakeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124D6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa232TwoSpeedAxleSwitch "SWTST_u8ComRdCcvs1Sa232TwoSpeedAxleSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124D4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa23BrakeSwitch "SWTST_u8ComRdCcvs1Sa23BrakeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124D3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa23ClutchSwitch "SWTST_u8ComRdCcvs1Sa23ClutchSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124D2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa23CruiseCtrlAccelerateSwitch "SWTST_u8ComRdCcvs1Sa23CruiseCtrlAccelerateSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124D1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa23CruiseCtrlActive "SWTST_u8ComRdCcvs1Sa23CruiseCtrlActive" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124D0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa23CruiseCtrlCoastSwitch "SWTST_u8ComRdCcvs1Sa23CruiseCtrlCoastSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124CF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa23CruiseCtrlEnableSwitch "SWTST_u8ComRdCcvs1Sa23CruiseCtrlEnableSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124CE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa23CruiseCtrlPauseSwitch "SWTST_u8ComRdCcvs1Sa23CruiseCtrlPauseSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124CD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa23CruiseCtrlResumeSwitch "SWTST_u8ComRdCcvs1Sa23CruiseCtrlResumeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124CC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa23CruiseCtrlSetSwitch "SWTST_u8ComRdCcvs1Sa23CruiseCtrlSetSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124CB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa23CruiseCtrlStates "SWTST_u8ComRdCcvs1Sa23CruiseCtrlStates" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124CA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa23EngIdleDecrementSwitch "SWTST_u8ComRdCcvs1Sa23EngIdleDecrementSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124C9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa23EngIdleIncrementSwitch "SWTST_u8ComRdCcvs1Sa23EngIdleIncrementSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124C8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa23EngShutdownOverrideSwitch "SWTST_u8ComRdCcvs1Sa23EngShutdownOverrideSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124C7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa23EngTestModeSwitch "SWTST_u8ComRdCcvs1Sa23EngTestModeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124C6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa23PTOGovernorState "SWTST_u8ComRdCcvs1Sa23PTOGovernorState" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124C3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa23ParkBrakeReleaseInhibitRq "SWTST_u8ComRdCcvs1Sa23ParkBrakeReleaseInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124C5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa23ParkingBrakeSwitch "SWTST_u8ComRdCcvs1Sa23ParkingBrakeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124C4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa23TwoSpeedAxleSwitch "SWTST_u8ComRdCcvs1Sa23TwoSpeedAxleSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124C2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa33BrakeSwitch "SWTST_u8ComRdCcvs1Sa33BrakeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124C1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa33ClutchSwitch "SWTST_u8ComRdCcvs1Sa33ClutchSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124C0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa33CruiseCtrlAccelerateSwitch "SWTST_u8ComRdCcvs1Sa33CruiseCtrlAccelerateSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124BF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa33CruiseCtrlActive "SWTST_u8ComRdCcvs1Sa33CruiseCtrlActive" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124BE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa33CruiseCtrlCoastSwitch "SWTST_u8ComRdCcvs1Sa33CruiseCtrlCoastSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124BD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa33CruiseCtrlEnableSwitch "SWTST_u8ComRdCcvs1Sa33CruiseCtrlEnableSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124BC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa33CruiseCtrlPauseSwitch "SWTST_u8ComRdCcvs1Sa33CruiseCtrlPauseSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124BB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa33CruiseCtrlResumeSwitch "SWTST_u8ComRdCcvs1Sa33CruiseCtrlResumeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124BA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa33CruiseCtrlSetSwitch "SWTST_u8ComRdCcvs1Sa33CruiseCtrlSetSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124B9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa33CruiseCtrlStates "SWTST_u8ComRdCcvs1Sa33CruiseCtrlStates" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124B8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa33EngIdleDecrementSwitch "SWTST_u8ComRdCcvs1Sa33EngIdleDecrementSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124B7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa33EngIdleIncrementSwitch "SWTST_u8ComRdCcvs1Sa33EngIdleIncrementSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124B6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa33EngShutdownOverrideSwitch "SWTST_u8ComRdCcvs1Sa33EngShutdownOverrideSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124B5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa33EngTestModeSwitch "SWTST_u8ComRdCcvs1Sa33EngTestModeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124B4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa33PTOGovernorState "SWTST_u8ComRdCcvs1Sa33PTOGovernorState" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124B1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa33ParkBrakeReleaseInhibitRq "SWTST_u8ComRdCcvs1Sa33ParkBrakeReleaseInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124B3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa33ParkingBrakeSwitch "SWTST_u8ComRdCcvs1Sa33ParkingBrakeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124B2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa33TwoSpeedAxleSwitch "SWTST_u8ComRdCcvs1Sa33TwoSpeedAxleSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124B0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa39BrakeSwitch "SWTST_u8ComRdCcvs1Sa39BrakeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124AF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa39ClutchSwitch "SWTST_u8ComRdCcvs1Sa39ClutchSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124AE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa39CruiseCtrlAccelerateSwitch "SWTST_u8ComRdCcvs1Sa39CruiseCtrlAccelerateSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124AD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa39CruiseCtrlActive "SWTST_u8ComRdCcvs1Sa39CruiseCtrlActive" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa39CruiseCtrlCoastSwitch "SWTST_u8ComRdCcvs1Sa39CruiseCtrlCoastSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124AB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa39CruiseCtrlEnableSwitch "SWTST_u8ComRdCcvs1Sa39CruiseCtrlEnableSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124AA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa39CruiseCtrlPauseSwitch "SWTST_u8ComRdCcvs1Sa39CruiseCtrlPauseSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124A9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa39CruiseCtrlResumeSwitch "SWTST_u8ComRdCcvs1Sa39CruiseCtrlResumeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124A8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa39CruiseCtrlSetSwitch "SWTST_u8ComRdCcvs1Sa39CruiseCtrlSetSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124A7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa39CruiseCtrlStates "SWTST_u8ComRdCcvs1Sa39CruiseCtrlStates" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124A6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa39EngIdleDecrementSwitch "SWTST_u8ComRdCcvs1Sa39EngIdleDecrementSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124A5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa39EngIdleIncrementSwitch "SWTST_u8ComRdCcvs1Sa39EngIdleIncrementSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124A4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa39EngShutdownOverrideSwitch "SWTST_u8ComRdCcvs1Sa39EngShutdownOverrideSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124A3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa39EngTestModeSwitch "SWTST_u8ComRdCcvs1Sa39EngTestModeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124A2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa39PTOGovernorState "SWTST_u8ComRdCcvs1Sa39PTOGovernorState" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001249F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa39ParkBrakeReleaseInhibitRq "SWTST_u8ComRdCcvs1Sa39ParkBrakeReleaseInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124A1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa39ParkingBrakeSwitch "SWTST_u8ComRdCcvs1Sa39ParkingBrakeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600124A0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa39TwoSpeedAxleSwitch "SWTST_u8ComRdCcvs1Sa39TwoSpeedAxleSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001249E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa49BrakeSwitch "SWTST_u8ComRdCcvs1Sa49BrakeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001249D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa49ClutchSwitch "SWTST_u8ComRdCcvs1Sa49ClutchSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001249C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa49CruiseCtrlAccelerateSwitch "SWTST_u8ComRdCcvs1Sa49CruiseCtrlAccelerateSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001249B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa49CruiseCtrlActive "SWTST_u8ComRdCcvs1Sa49CruiseCtrlActive" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001249A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa49CruiseCtrlCoastSwitch "SWTST_u8ComRdCcvs1Sa49CruiseCtrlCoastSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012499 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa49CruiseCtrlEnableSwitch "SWTST_u8ComRdCcvs1Sa49CruiseCtrlEnableSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012498 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa49CruiseCtrlPauseSwitch "SWTST_u8ComRdCcvs1Sa49CruiseCtrlPauseSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012497 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa49CruiseCtrlResumeSwitch "SWTST_u8ComRdCcvs1Sa49CruiseCtrlResumeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012496 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa49CruiseCtrlSetSwitch "SWTST_u8ComRdCcvs1Sa49CruiseCtrlSetSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012495 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa49CruiseCtrlStates "SWTST_u8ComRdCcvs1Sa49CruiseCtrlStates" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012494 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa49EngIdleDecrementSwitch "SWTST_u8ComRdCcvs1Sa49EngIdleDecrementSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012493 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa49EngIdleIncrementSwitch "SWTST_u8ComRdCcvs1Sa49EngIdleIncrementSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012492 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa49EngShutdownOverrideSwitch "SWTST_u8ComRdCcvs1Sa49EngShutdownOverrideSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012491 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa49EngTestModeSwitch "SWTST_u8ComRdCcvs1Sa49EngTestModeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012490 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa49PTOGovernorState "SWTST_u8ComRdCcvs1Sa49PTOGovernorState" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001248D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa49ParkBrakeReleaseInhibitRq "SWTST_u8ComRdCcvs1Sa49ParkBrakeReleaseInhibitRq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001248F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa49ParkingBrakeSwitch "SWTST_u8ComRdCcvs1Sa49ParkingBrakeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001248E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdCcvs1Sa49TwoSpeedAxleSwitch "SWTST_u8ComRdCcvs1Sa49TwoSpeedAxleSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001248C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa00ABSEBSAmberWarningSignal "SWTST_u8ComRdEbc1Sa00ABSEBSAmberWarningSignal" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001248B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa00ABSFullyOperational "SWTST_u8ComRdEbc1Sa00ABSFullyOperational" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001248A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa00ABSOffroadSwitch "SWTST_u8ComRdEbc1Sa00ABSOffroadSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012489 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa00ASRBrakeCtrlActive "SWTST_u8ComRdEbc1Sa00ASRBrakeCtrlActive" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012486 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa00ASREngCtrlActive "SWTST_u8ComRdEbc1Sa00ASREngCtrlActive" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012485 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa00ASRHillHolderSwitch "SWTST_u8ComRdEbc1Sa00ASRHillHolderSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012484 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa00ASROffroadSwitch "SWTST_u8ComRdEbc1Sa00ASROffroadSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012483 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa00ATCASRInformationSignal "SWTST_u8ComRdEbc1Sa00ATCASRInformationSignal" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012482 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa00AccelInterlockSwitch "SWTST_u8ComRdEbc1Sa00AccelInterlockSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012488 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa00AntiLockBrakingActive "SWTST_u8ComRdEbc1Sa00AntiLockBrakingActive" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012487 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa00EBSBrakeSwitch "SWTST_u8ComRdEbc1Sa00EBSBrakeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012481 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa00EBSRedWarningSignal "SWTST_u8ComRdEbc1Sa00EBSRedWarningSignal" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012480 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa00EngAuxShutdownSwitch "SWTST_u8ComRdEbc1Sa00EngAuxShutdownSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001247F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa00EngDerateSwitch "SWTST_u8ComRdEbc1Sa00EngDerateSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001247E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa00HaltBrakeSwitch "SWTST_u8ComRdEbc1Sa00HaltBrakeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001247D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa00RemoteAccelEnableSwitch "SWTST_u8ComRdEbc1Sa00RemoteAccelEnableSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001247C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa00SrcAddrssOfCntrllngDvcFrBrkeCtrl "SWTST_u8ComRdEbc1Sa00SrcAddrssOfCntrllngDvcFrBrkeCtrl" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001247B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa00TractionCtrlOverrideSwitch "SWTST_u8ComRdEbc1Sa00TractionCtrlOverrideSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001247A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa00TrailerABSStatus "SWTST_u8ComRdEbc1Sa00TrailerABSStatus" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012479 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa00TrctrMntdTrailerABSWarningSignal "SWTST_u8ComRdEbc1Sa00TrctrMntdTrailerABSWarningSignal" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012478 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa11ABSEBSAmberWarningSignal "SWTST_u8ComRdEbc1Sa11ABSEBSAmberWarningSignal" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012477 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa11ABSFullyOperational "SWTST_u8ComRdEbc1Sa11ABSFullyOperational" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012476 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa11ABSOffroadSwitch "SWTST_u8ComRdEbc1Sa11ABSOffroadSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012475 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa11ASRBrakeCtrlActive "SWTST_u8ComRdEbc1Sa11ASRBrakeCtrlActive" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012472 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa11ASREngCtrlActive "SWTST_u8ComRdEbc1Sa11ASREngCtrlActive" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012471 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa11ASRHillHolderSwitch "SWTST_u8ComRdEbc1Sa11ASRHillHolderSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012470 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa11ASROffroadSwitch "SWTST_u8ComRdEbc1Sa11ASROffroadSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001246F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa11ATCASRInformationSignal "SWTST_u8ComRdEbc1Sa11ATCASRInformationSignal" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001246E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa11AccelInterlockSwitch "SWTST_u8ComRdEbc1Sa11AccelInterlockSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012474 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa11AntiLockBrakingActive "SWTST_u8ComRdEbc1Sa11AntiLockBrakingActive" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012473 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa11EBSBrakeSwitch "SWTST_u8ComRdEbc1Sa11EBSBrakeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001246D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa11EBSRedWarningSignal "SWTST_u8ComRdEbc1Sa11EBSRedWarningSignal" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001246C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa11EngAuxShutdownSwitch "SWTST_u8ComRdEbc1Sa11EngAuxShutdownSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001246B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa11EngDerateSwitch "SWTST_u8ComRdEbc1Sa11EngDerateSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001246A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa11HaltBrakeSwitch "SWTST_u8ComRdEbc1Sa11HaltBrakeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012469 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa11RemoteAccelEnableSwitch "SWTST_u8ComRdEbc1Sa11RemoteAccelEnableSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012468 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa11SrcAddrssOfCntrllngDvcFrBrkeCtrl "SWTST_u8ComRdEbc1Sa11SrcAddrssOfCntrllngDvcFrBrkeCtrl" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012467 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa11TractionCtrlOverrideSwitch "SWTST_u8ComRdEbc1Sa11TractionCtrlOverrideSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012466 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa11TrailerABSStatus "SWTST_u8ComRdEbc1Sa11TrailerABSStatus" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012465 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa11TrctrMntdTrailerABSWarningSignal "SWTST_u8ComRdEbc1Sa11TrctrMntdTrailerABSWarningSignal" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012464 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa23ABSEBSAmberWarningSignal "SWTST_u8ComRdEbc1Sa23ABSEBSAmberWarningSignal" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012463 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa23ABSFullyOperational "SWTST_u8ComRdEbc1Sa23ABSFullyOperational" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012462 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa23ABSOffroadSwitch "SWTST_u8ComRdEbc1Sa23ABSOffroadSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012461 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa23ASRBrakeCtrlActive "SWTST_u8ComRdEbc1Sa23ASRBrakeCtrlActive" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001245E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa23ASREngCtrlActive "SWTST_u8ComRdEbc1Sa23ASREngCtrlActive" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001245D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa23ASRHillHolderSwitch "SWTST_u8ComRdEbc1Sa23ASRHillHolderSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001245C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa23ASROffroadSwitch "SWTST_u8ComRdEbc1Sa23ASROffroadSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001245B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa23ATCASRInformationSignal "SWTST_u8ComRdEbc1Sa23ATCASRInformationSignal" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001245A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa23AccelInterlockSwitch "SWTST_u8ComRdEbc1Sa23AccelInterlockSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012460 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa23AntiLockBrakingActive "SWTST_u8ComRdEbc1Sa23AntiLockBrakingActive" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001245F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa23EBSBrakeSwitch "SWTST_u8ComRdEbc1Sa23EBSBrakeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012459 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa23EBSRedWarningSignal "SWTST_u8ComRdEbc1Sa23EBSRedWarningSignal" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012458 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa23EngAuxShutdownSwitch "SWTST_u8ComRdEbc1Sa23EngAuxShutdownSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012457 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa23EngDerateSwitch "SWTST_u8ComRdEbc1Sa23EngDerateSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012456 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa23HaltBrakeSwitch "SWTST_u8ComRdEbc1Sa23HaltBrakeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012455 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa23RemoteAccelEnableSwitch "SWTST_u8ComRdEbc1Sa23RemoteAccelEnableSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012454 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa23SrcAddrssOfCntrllngDvcFrBrkeCtrl "SWTST_u8ComRdEbc1Sa23SrcAddrssOfCntrllngDvcFrBrkeCtrl" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012453 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa23TractionCtrlOverrideSwitch "SWTST_u8ComRdEbc1Sa23TractionCtrlOverrideSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012452 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa23TrailerABSStatus "SWTST_u8ComRdEbc1Sa23TrailerABSStatus" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012451 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa23TrctrMntdTrailerABSWarningSignal "SWTST_u8ComRdEbc1Sa23TrctrMntdTrailerABSWarningSignal" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012450 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa33ABSEBSAmberWarningSignal "SWTST_u8ComRdEbc1Sa33ABSEBSAmberWarningSignal" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001244F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa33ABSFullyOperational "SWTST_u8ComRdEbc1Sa33ABSFullyOperational" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001244E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa33ABSOffroadSwitch "SWTST_u8ComRdEbc1Sa33ABSOffroadSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001244D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa33ASRBrakeCtrlActive "SWTST_u8ComRdEbc1Sa33ASRBrakeCtrlActive" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001244A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa33ASREngCtrlActive "SWTST_u8ComRdEbc1Sa33ASREngCtrlActive" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012449 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa33ASRHillHolderSwitch "SWTST_u8ComRdEbc1Sa33ASRHillHolderSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012448 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa33ASROffroadSwitch "SWTST_u8ComRdEbc1Sa33ASROffroadSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012447 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa33ATCASRInformationSignal "SWTST_u8ComRdEbc1Sa33ATCASRInformationSignal" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012446 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa33AccelInterlockSwitch "SWTST_u8ComRdEbc1Sa33AccelInterlockSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001244C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa33AntiLockBrakingActive "SWTST_u8ComRdEbc1Sa33AntiLockBrakingActive" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001244B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa33EBSBrakeSwitch "SWTST_u8ComRdEbc1Sa33EBSBrakeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012445 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa33EBSRedWarningSignal "SWTST_u8ComRdEbc1Sa33EBSRedWarningSignal" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012444 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa33EngAuxShutdownSwitch "SWTST_u8ComRdEbc1Sa33EngAuxShutdownSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012443 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa33EngDerateSwitch "SWTST_u8ComRdEbc1Sa33EngDerateSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012442 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa33HaltBrakeSwitch "SWTST_u8ComRdEbc1Sa33HaltBrakeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012441 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa33RemoteAccelEnableSwitch "SWTST_u8ComRdEbc1Sa33RemoteAccelEnableSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012440 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa33SrcAddrssOfCntrllngDvcFrBrkeCtrl "SWTST_u8ComRdEbc1Sa33SrcAddrssOfCntrllngDvcFrBrkeCtrl" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001243F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa33TractionCtrlOverrideSwitch "SWTST_u8ComRdEbc1Sa33TractionCtrlOverrideSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001243E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa33TrailerABSStatus "SWTST_u8ComRdEbc1Sa33TrailerABSStatus" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001243D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa33TrctrMntdTrailerABSWarningSignal "SWTST_u8ComRdEbc1Sa33TrctrMntdTrailerABSWarningSignal" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001243C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa49ABSEBSAmberWarningSignal "SWTST_u8ComRdEbc1Sa49ABSEBSAmberWarningSignal" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001243B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa49ABSFullyOperational "SWTST_u8ComRdEbc1Sa49ABSFullyOperational" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001243A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa49ABSOffroadSwitch "SWTST_u8ComRdEbc1Sa49ABSOffroadSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012439 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa49ASRBrakeCtrlActive "SWTST_u8ComRdEbc1Sa49ASRBrakeCtrlActive" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012436 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa49ASREngCtrlActive "SWTST_u8ComRdEbc1Sa49ASREngCtrlActive" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012435 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa49ASRHillHolderSwitch "SWTST_u8ComRdEbc1Sa49ASRHillHolderSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012434 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa49ASROffroadSwitch "SWTST_u8ComRdEbc1Sa49ASROffroadSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012433 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa49ATCASRInformationSignal "SWTST_u8ComRdEbc1Sa49ATCASRInformationSignal" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012432 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa49AccelInterlockSwitch "SWTST_u8ComRdEbc1Sa49AccelInterlockSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012438 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa49AntiLockBrakingActive "SWTST_u8ComRdEbc1Sa49AntiLockBrakingActive" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012437 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa49EBSBrakeSwitch "SWTST_u8ComRdEbc1Sa49EBSBrakeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012431 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa49EBSRedWarningSignal "SWTST_u8ComRdEbc1Sa49EBSRedWarningSignal" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012430 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa49EngAuxShutdownSwitch "SWTST_u8ComRdEbc1Sa49EngAuxShutdownSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001242F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa49EngDerateSwitch "SWTST_u8ComRdEbc1Sa49EngDerateSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001242E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa49HaltBrakeSwitch "SWTST_u8ComRdEbc1Sa49HaltBrakeSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001242D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa49RemoteAccelEnableSwitch "SWTST_u8ComRdEbc1Sa49RemoteAccelEnableSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001242C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa49SrcAddrssOfCntrllngDvcFrBrkeCtrl "SWTST_u8ComRdEbc1Sa49SrcAddrssOfCntrllngDvcFrBrkeCtrl" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001242B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa49TractionCtrlOverrideSwitch "SWTST_u8ComRdEbc1Sa49TractionCtrlOverrideSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001242A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa49TrailerABSStatus "SWTST_u8ComRdEbc1Sa49TrailerABSStatus" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012429 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEbc1Sa49TrctrMntdTrailerABSWarningSignal "SWTST_u8ComRdEbc1Sa49TrctrMntdTrailerABSWarningSignal" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012428 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEc1Sa00SupportTSC1CtrlPurposeGroup1 "SWTST_u8ComRdEc1Sa00SupportTSC1CtrlPurposeGroup1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012427 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEc1Sa00SupportTSC1CtrlPurposeGroup2 "SWTST_u8ComRdEc1Sa00SupportTSC1CtrlPurposeGroup2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012426 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEc1Sa00SupportTSC1CtrlPurposeGroup3 "SWTST_u8ComRdEc1Sa00SupportTSC1CtrlPurposeGroup3" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012425 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEc1Sa00SupportTSC1CtrlPurposeGroup4 "SWTST_u8ComRdEc1Sa00SupportTSC1CtrlPurposeGroup4" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012424 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEc1Sa00SupportVariableRateTSC1Message "SWTST_u8ComRdEc1Sa00SupportVariableRateTSC1Message" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012423 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec1Sa00EngStarterMode "SWTST_u8ComRdEec1Sa00EngStarterMode" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012422 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec1Sa00EngTorqueMode "SWTST_u8ComRdEec1Sa00EngTorqueMode" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012421 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec1Sa00SrcAddrssOfCntrllngDvcForEngCtrl "SWTST_u8ComRdEec1Sa00SrcAddrssOfCntrllngDvcForEngCtrl" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012420 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec2Sa00AccelPedal1LowIdleSwitch "SWTST_u8ComRdEec2Sa00AccelPedal1LowIdleSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001241F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec2Sa00AccelPedal2LowIdleSwitch "SWTST_u8ComRdEec2Sa00AccelPedal2LowIdleSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001241E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec2Sa00AccelPedalKickdownSwitch "SWTST_u8ComRdEec2Sa00AccelPedalKickdownSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001241D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec2Sa00DPFThermalManagementActive "SWTST_u8ComRdEec2Sa00DPFThermalManagementActive" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001241C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec2Sa00MmntaryEngMaxPowerEnableFeedback "SWTST_u8ComRdEec2Sa00MmntaryEngMaxPowerEnableFeedback" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001241B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec2Sa00RoadSpeedLimitStatus "SWTST_u8ComRdEec2Sa00RoadSpeedLimitStatus" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001241A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec2Sa00SCRThermalManagementActive "SWTST_u8ComRdEec2Sa00SCRThermalManagementActive" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012419 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec2Sa00VhcleAccelerationRateLimitStatus "SWTST_u8ComRdEec2Sa00VhcleAccelerationRateLimitStatus" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012418 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec2Sa17AccelPedal1LowIdleSwitch "SWTST_u8ComRdEec2Sa17AccelPedal1LowIdleSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012417 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec2Sa17AccelPedal2LowIdleSwitch "SWTST_u8ComRdEec2Sa17AccelPedal2LowIdleSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012416 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec2Sa17AccelPedalKickdownSwitch "SWTST_u8ComRdEec2Sa17AccelPedalKickdownSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012415 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec2Sa17DPFThermalManagementActive "SWTST_u8ComRdEec2Sa17DPFThermalManagementActive" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012414 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec2Sa17MmntaryEngMaxPowerEnableFeedback "SWTST_u8ComRdEec2Sa17MmntaryEngMaxPowerEnableFeedback" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012413 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec2Sa17RoadSpeedLimitStatus "SWTST_u8ComRdEec2Sa17RoadSpeedLimitStatus" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012412 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec2Sa17SCRThermalManagementActive "SWTST_u8ComRdEec2Sa17SCRThermalManagementActive" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012411 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec2Sa17VhcleAccelerationRateLimitStatus "SWTST_u8ComRdEec2Sa17VhcleAccelerationRateLimitStatus" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012410 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec2Sa33AccelPedal1LowIdleSwitch "SWTST_u8ComRdEec2Sa33AccelPedal1LowIdleSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001240F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec2Sa33AccelPedal2LowIdleSwitch "SWTST_u8ComRdEec2Sa33AccelPedal2LowIdleSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001240E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec2Sa33AccelPedalKickdownSwitch "SWTST_u8ComRdEec2Sa33AccelPedalKickdownSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001240D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec2Sa33DPFThermalManagementActive "SWTST_u8ComRdEec2Sa33DPFThermalManagementActive" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001240C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec2Sa33MmntaryEngMaxPowerEnableFeedback "SWTST_u8ComRdEec2Sa33MmntaryEngMaxPowerEnableFeedback" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001240B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec2Sa33RoadSpeedLimitStatus "SWTST_u8ComRdEec2Sa33RoadSpeedLimitStatus" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001240A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec2Sa33SCRThermalManagementActive "SWTST_u8ComRdEec2Sa33SCRThermalManagementActive" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012409 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec2Sa33VhcleAccelerationRateLimitStatus "SWTST_u8ComRdEec2Sa33VhcleAccelerationRateLimitStatus" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012408 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec2Sa49AccelPedal1LowIdleSwitch "SWTST_u8ComRdEec2Sa49AccelPedal1LowIdleSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012407 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec2Sa49AccelPedal2LowIdleSwitch "SWTST_u8ComRdEec2Sa49AccelPedal2LowIdleSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012406 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec2Sa49AccelPedalKickdownSwitch "SWTST_u8ComRdEec2Sa49AccelPedalKickdownSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012405 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec2Sa49DPFThermalManagementActive "SWTST_u8ComRdEec2Sa49DPFThermalManagementActive" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012404 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec2Sa49MmntaryEngMaxPowerEnableFeedback "SWTST_u8ComRdEec2Sa49MmntaryEngMaxPowerEnableFeedback" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012403 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec2Sa49RoadSpeedLimitStatus "SWTST_u8ComRdEec2Sa49RoadSpeedLimitStatus" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012402 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec2Sa49SCRThermalManagementActive "SWTST_u8ComRdEec2Sa49SCRThermalManagementActive" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012401 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec2Sa49VhcleAccelerationRateLimitStatus "SWTST_u8ComRdEec2Sa49VhcleAccelerationRateLimitStatus" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012400 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec3Sa00AFT1ExhDewPoint "SWTST_u8ComRdEec3Sa00AFT1ExhDewPoint" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123FF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec3Sa00AFT1InDewPoint "SWTST_u8ComRdEec3Sa00AFT1InDewPoint" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123FE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec3Sa00AFT2ExhDewPoint "SWTST_u8ComRdEec3Sa00AFT2ExhDewPoint" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123FD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdEec3Sa00AFT2InDewPoint "SWTST_u8ComRdEec3Sa00AFT2InDewPoint" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123FC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa00EngCoolantLoadIncrease "SWTST_u8ComRdErc1Sa00EngCoolantLoadIncrease" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123FB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa00RetarderEnableBrakeAssistSwitch "SWTST_u8ComRdErc1Sa00RetarderEnableBrakeAssistSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123FA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa00RetarderEnableShiftAssistSwitch "SWTST_u8ComRdErc1Sa00RetarderEnableShiftAssistSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123F9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa00RetarderRequestingBrakeLight "SWTST_u8ComRdErc1Sa00RetarderRequestingBrakeLight" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123F8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa00RetarderRoadSpeedExceededStatus "SWTST_u8ComRdErc1Sa00RetarderRoadSpeedExceededStatus" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123F7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa00RetarderRoadSpeedLimitSwitch "SWTST_u8ComRdErc1Sa00RetarderRoadSpeedLimitSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123F6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa00RetarderTorqueMode "SWTST_u8ComRdErc1Sa00RetarderTorqueMode" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123F5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa00SrcAddrssOfCntrllngDvcFrRtrdrCtr "SWTST_u8ComRdErc1Sa00SrcAddrssOfCntrllngDvcFrRtrdrCtr" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123F4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa15EngCoolantLoadIncrease "SWTST_u8ComRdErc1Sa15EngCoolantLoadIncrease" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123F3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa15RetarderEnableBrakeAssistSwitch "SWTST_u8ComRdErc1Sa15RetarderEnableBrakeAssistSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123F2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa15RetarderEnableShiftAssistSwitch "SWTST_u8ComRdErc1Sa15RetarderEnableShiftAssistSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123F1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa15RetarderRequestingBrakeLight "SWTST_u8ComRdErc1Sa15RetarderRequestingBrakeLight" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123F0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa15RetarderRoadSpeedExceededStatus "SWTST_u8ComRdErc1Sa15RetarderRoadSpeedExceededStatus" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123EF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa15RetarderRoadSpeedLimitSwitch "SWTST_u8ComRdErc1Sa15RetarderRoadSpeedLimitSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123EE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa15RetarderTorqueMode "SWTST_u8ComRdErc1Sa15RetarderTorqueMode" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123ED READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa15SrcAddrssOfCntrllngDvcFrRtrdrCtr "SWTST_u8ComRdErc1Sa15SrcAddrssOfCntrllngDvcFrRtrdrCtr" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123EC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa23EngCoolantLoadIncrease "SWTST_u8ComRdErc1Sa23EngCoolantLoadIncrease" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123EB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa23RetarderEnableBrakeAssistSwitch "SWTST_u8ComRdErc1Sa23RetarderEnableBrakeAssistSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123EA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa23RetarderEnableShiftAssistSwitch "SWTST_u8ComRdErc1Sa23RetarderEnableShiftAssistSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123E9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa23RetarderRequestingBrakeLight "SWTST_u8ComRdErc1Sa23RetarderRequestingBrakeLight" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123E8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa23RetarderRoadSpeedExceededStatus "SWTST_u8ComRdErc1Sa23RetarderRoadSpeedExceededStatus" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123E7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa23RetarderRoadSpeedLimitSwitch "SWTST_u8ComRdErc1Sa23RetarderRoadSpeedLimitSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123E6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa23RetarderTorqueMode "SWTST_u8ComRdErc1Sa23RetarderTorqueMode" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123E5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa23SrcAddrssOfCntrllngDvcFrRtrdrCtr "SWTST_u8ComRdErc1Sa23SrcAddrssOfCntrllngDvcFrRtrdrCtr" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123E4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa33EngCoolantLoadIncrease "SWTST_u8ComRdErc1Sa33EngCoolantLoadIncrease" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123E3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa33RetarderEnableBrakeAssistSwitch "SWTST_u8ComRdErc1Sa33RetarderEnableBrakeAssistSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123E2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa33RetarderEnableShiftAssistSwitch "SWTST_u8ComRdErc1Sa33RetarderEnableShiftAssistSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123E1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa33RetarderRequestingBrakeLight "SWTST_u8ComRdErc1Sa33RetarderRequestingBrakeLight" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123E0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa33RetarderRoadSpeedExceededStatus "SWTST_u8ComRdErc1Sa33RetarderRoadSpeedExceededStatus" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123DF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa33RetarderRoadSpeedLimitSwitch "SWTST_u8ComRdErc1Sa33RetarderRoadSpeedLimitSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123DE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa33RetarderTorqueMode "SWTST_u8ComRdErc1Sa33RetarderTorqueMode" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123DD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa33SrcAddrssOfCntrllngDvcFrRtrdrCtr "SWTST_u8ComRdErc1Sa33SrcAddrssOfCntrllngDvcFrRtrdrCtr" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123DC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa41EngCoolantLoadIncrease "SWTST_u8ComRdErc1Sa41EngCoolantLoadIncrease" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123DB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa41RetarderEnableBrakeAssistSwitch "SWTST_u8ComRdErc1Sa41RetarderEnableBrakeAssistSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123DA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa41RetarderEnableShiftAssistSwitch "SWTST_u8ComRdErc1Sa41RetarderEnableShiftAssistSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123D9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa41RetarderRequestingBrakeLight "SWTST_u8ComRdErc1Sa41RetarderRequestingBrakeLight" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123D8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa41RetarderRoadSpeedExceededStatus "SWTST_u8ComRdErc1Sa41RetarderRoadSpeedExceededStatus" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123D7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa41RetarderRoadSpeedLimitSwitch "SWTST_u8ComRdErc1Sa41RetarderRoadSpeedLimitSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123D6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa41RetarderTorqueMode "SWTST_u8ComRdErc1Sa41RetarderTorqueMode" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123D5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa41SrcAddrssOfCntrllngDvcFrRtrdrCtr "SWTST_u8ComRdErc1Sa41SrcAddrssOfCntrllngDvcFrRtrdrCtr" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123D4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa49EngCoolantLoadIncrease "SWTST_u8ComRdErc1Sa49EngCoolantLoadIncrease" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123D3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa49RetarderEnableBrakeAssistSwitch "SWTST_u8ComRdErc1Sa49RetarderEnableBrakeAssistSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123D2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa49RetarderEnableShiftAssistSwitch "SWTST_u8ComRdErc1Sa49RetarderEnableShiftAssistSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123D1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa49RetarderRequestingBrakeLight "SWTST_u8ComRdErc1Sa49RetarderRequestingBrakeLight" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123D0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa49RetarderRoadSpeedExceededStatus "SWTST_u8ComRdErc1Sa49RetarderRoadSpeedExceededStatus" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123CF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa49RetarderRoadSpeedLimitSwitch "SWTST_u8ComRdErc1Sa49RetarderRoadSpeedLimitSwitch" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123CE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa49RetarderTorqueMode "SWTST_u8ComRdErc1Sa49RetarderTorqueMode" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123CD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdErc1Sa49SrcAddrssOfCntrllngDvcFrRtrdrCtr "SWTST_u8ComRdErc1Sa49SrcAddrssOfCntrllngDvcFrRtrdrCtr" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123CC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa23AtLeastOnePTOEngaged "SWTST_u8ComRdPtodeSa23AtLeastOnePTOEngaged" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123CB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa23EnableSwitchPTOEngFlywheel "SWTST_u8ComRdPtodeSa23EnableSwitchPTOEngFlywheel" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123CA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa23EnableSwitchTransInputShaftPTO1 "SWTST_u8ComRdPtodeSa23EnableSwitchTransInputShaftPTO1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123C9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa23EnableSwitchTransInputShaftPTO2 "SWTST_u8ComRdPtodeSa23EnableSwitchTransInputShaftPTO2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123C8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa23EnableSwitchTransOutputShaftPTO "SWTST_u8ComRdPtodeSa23EnableSwitchTransOutputShaftPTO" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123C7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa23EnblSwtchTrnsfrCseOutputShaftPTO "SWTST_u8ComRdPtodeSa23EnblSwtchTrnsfrCseOutputShaftPTO" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123C4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa23EnbleSwitchPTOEngAccessoryDrive1 "SWTST_u8ComRdPtodeSa23EnbleSwitchPTOEngAccessoryDrive1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123C6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa23EnbleSwitchPTOEngAccessoryDrive2 "SWTST_u8ComRdPtodeSa23EnbleSwitchPTOEngAccessoryDrive2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123C5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa23EngagementConsentPTOEngFlywheel "SWTST_u8ComRdPtodeSa23EngagementConsentPTOEngFlywheel" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123C3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa23EngagementStatusPTOEngFlywheel "SWTST_u8ComRdPtodeSa23EngagementStatusPTOEngFlywheel" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123C2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa23EnggmntCnsentTransInputShaftPTO1 "SWTST_u8ComRdPtodeSa23EnggmntCnsentTransInputShaftPTO1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123C1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa23EnggmntCnsentTransInputShaftPTO2 "SWTST_u8ComRdPtodeSa23EnggmntCnsentTransInputShaftPTO2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123C0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa23EnggmntCnsentTransOutputShaftPTO "SWTST_u8ComRdPtodeSa23EnggmntCnsentTransOutputShaftPTO" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123BF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa23EnggmntCnsntPTOEngAccssoryDrive1 "SWTST_u8ComRdPtodeSa23EnggmntCnsntPTOEngAccssoryDrive1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123BE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa23EnggmntCnsntPTOEngAccssoryDrive2 "SWTST_u8ComRdPtodeSa23EnggmntCnsntPTOEngAccssoryDrive2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123BD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa23EnggmntCnsntTrnsfrCsOtptShaftPTO "SWTST_u8ComRdPtodeSa23EnggmntCnsntTrnsfrCsOtptShaftPTO" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123BC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa23EnggmntStatusTransInputShaftPTO1 "SWTST_u8ComRdPtodeSa23EnggmntStatusTransInputShaftPTO1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123BB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa23EnggmntStatusTransInputShaftPTO2 "SWTST_u8ComRdPtodeSa23EnggmntStatusTransInputShaftPTO2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123BA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa23EnggmntStatusTransOutputShaftPTO "SWTST_u8ComRdPtodeSa23EnggmntStatusTransOutputShaftPTO" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123B9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa23EnggmntSttsPTOEngAccessoryDrive1 "SWTST_u8ComRdPtodeSa23EnggmntSttsPTOEngAccessoryDrive1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123B8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa23EnggmntSttsPTOEngAccessoryDrive2 "SWTST_u8ComRdPtodeSa23EnggmntSttsPTOEngAccessoryDrive2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123B7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa23EnggmntSttsTrnsfrCsOtputShaftPTO "SWTST_u8ComRdPtodeSa23EnggmntSttsTrnsfrCsOtputShaftPTO" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123B6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa33AtLeastOnePTOEngaged "SWTST_u8ComRdPtodeSa33AtLeastOnePTOEngaged" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123B5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa33EnableSwitchPTOEngFlywheel "SWTST_u8ComRdPtodeSa33EnableSwitchPTOEngFlywheel" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123B4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa33EnableSwitchTransInputShaftPTO1 "SWTST_u8ComRdPtodeSa33EnableSwitchTransInputShaftPTO1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123B3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa33EnableSwitchTransInputShaftPTO2 "SWTST_u8ComRdPtodeSa33EnableSwitchTransInputShaftPTO2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123B2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa33EnableSwitchTransOutputShaftPTO "SWTST_u8ComRdPtodeSa33EnableSwitchTransOutputShaftPTO" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123B1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa33EnblSwtchTrnsfrCseOutputShaftPTO "SWTST_u8ComRdPtodeSa33EnblSwtchTrnsfrCseOutputShaftPTO" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123AE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa33EnbleSwitchPTOEngAccessoryDrive1 "SWTST_u8ComRdPtodeSa33EnbleSwitchPTOEngAccessoryDrive1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123B0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa33EnbleSwitchPTOEngAccessoryDrive2 "SWTST_u8ComRdPtodeSa33EnbleSwitchPTOEngAccessoryDrive2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123AF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa33EngagementConsentPTOEngFlywheel "SWTST_u8ComRdPtodeSa33EngagementConsentPTOEngFlywheel" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123AD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa33EngagementStatusPTOEngFlywheel "SWTST_u8ComRdPtodeSa33EngagementStatusPTOEngFlywheel" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa33EnggmntCnsentTransInputShaftPTO1 "SWTST_u8ComRdPtodeSa33EnggmntCnsentTransInputShaftPTO1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123AB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa33EnggmntCnsentTransInputShaftPTO2 "SWTST_u8ComRdPtodeSa33EnggmntCnsentTransInputShaftPTO2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123AA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa33EnggmntCnsentTransOutputShaftPTO "SWTST_u8ComRdPtodeSa33EnggmntCnsentTransOutputShaftPTO" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123A9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa33EnggmntCnsntPTOEngAccssoryDrive1 "SWTST_u8ComRdPtodeSa33EnggmntCnsntPTOEngAccssoryDrive1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123A8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa33EnggmntCnsntPTOEngAccssoryDrive2 "SWTST_u8ComRdPtodeSa33EnggmntCnsntPTOEngAccssoryDrive2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123A7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa33EnggmntCnsntTrnsfrCsOtptShaftPTO "SWTST_u8ComRdPtodeSa33EnggmntCnsntTrnsfrCsOtptShaftPTO" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123A6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa33EnggmntStatusTransInputShaftPTO1 "SWTST_u8ComRdPtodeSa33EnggmntStatusTransInputShaftPTO1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123A5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa33EnggmntStatusTransInputShaftPTO2 "SWTST_u8ComRdPtodeSa33EnggmntStatusTransInputShaftPTO2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123A4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa33EnggmntStatusTransOutputShaftPTO "SWTST_u8ComRdPtodeSa33EnggmntStatusTransOutputShaftPTO" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123A3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa33EnggmntSttsPTOEngAccessoryDrive1 "SWTST_u8ComRdPtodeSa33EnggmntSttsPTOEngAccessoryDrive1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123A2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa33EnggmntSttsPTOEngAccessoryDrive2 "SWTST_u8ComRdPtodeSa33EnggmntSttsPTOEngAccessoryDrive2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123A1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa33EnggmntSttsTrnsfrCsOtputShaftPTO "SWTST_u8ComRdPtodeSa33EnggmntSttsTrnsfrCsOtputShaftPTO" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600123A0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa49AtLeastOnePTOEngaged "SWTST_u8ComRdPtodeSa49AtLeastOnePTOEngaged" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001239F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa49EnableSwitchPTOEngFlywheel "SWTST_u8ComRdPtodeSa49EnableSwitchPTOEngFlywheel" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001239E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa49EnableSwitchTransInputShaftPTO1 "SWTST_u8ComRdPtodeSa49EnableSwitchTransInputShaftPTO1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001239D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa49EnableSwitchTransInputShaftPTO2 "SWTST_u8ComRdPtodeSa49EnableSwitchTransInputShaftPTO2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001239C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa49EnableSwitchTransOutputShaftPTO "SWTST_u8ComRdPtodeSa49EnableSwitchTransOutputShaftPTO" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001239B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa49EnblSwtchTrnsfrCseOutputShaftPTO "SWTST_u8ComRdPtodeSa49EnblSwtchTrnsfrCseOutputShaftPTO" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012398 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa49EnbleSwitchPTOEngAccessoryDrive1 "SWTST_u8ComRdPtodeSa49EnbleSwitchPTOEngAccessoryDrive1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001239A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa49EnbleSwitchPTOEngAccessoryDrive2 "SWTST_u8ComRdPtodeSa49EnbleSwitchPTOEngAccessoryDrive2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012399 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa49EngagementConsentPTOEngFlywheel "SWTST_u8ComRdPtodeSa49EngagementConsentPTOEngFlywheel" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012397 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa49EngagementStatusPTOEngFlywheel "SWTST_u8ComRdPtodeSa49EngagementStatusPTOEngFlywheel" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012396 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa49EnggmntCnsentTransInputShaftPTO1 "SWTST_u8ComRdPtodeSa49EnggmntCnsentTransInputShaftPTO1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012395 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa49EnggmntCnsentTransInputShaftPTO2 "SWTST_u8ComRdPtodeSa49EnggmntCnsentTransInputShaftPTO2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012394 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u8ComRdPtodeSa49EnggmntCnsentTransOutputShaftPTO "SWTST_u8ComRdPtodeSa49EnggmntCnsentTransOutputShaftPTO" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012393 READ_WRITE /end MEASUREMENT
/begin COMPU_METHOD I_5 "" RAT_FUNC "%9.2" "-" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin FUNCTION SWTST "" FUNCTION_VERSION "NONE_"
 /begin OUT_MEASUREMENT SWTST_u32CalibTst3[94] SWTST_u32CalibTst3[95] SWTST_u32CalibTst3[96] SWTST_u32CalibTst3[97] SWTST_u32CalibTst3[98] SWTST_u32CalibTst3[99] SWTST_u32CalibTst3[9] SWTST_u32CalibTst4 SWTST_u32CalibTst4[0] SWTST_u32CalibTst4[10] SWTST_u32CalibTst4[11] SWTST_u32CalibTst4[12] SWTST_u32CalibTst4[13] SWTST_u32CalibTst4[14] SWTST_u32CalibTst4[15] SWTST_u32CalibTst4[16] SWTST_u32CalibTst4[17] SWTST_u32CalibTst4[18] SWTST_u32CalibTst4[19] SWTST_u32CalibTst4[1] SWTST_u32CalibTst4[20] SWTST_u32CalibTst4[21] SWTST_u32CalibTst4[22] SWTST_u32CalibTst4[23] SWTST_u32CalibTst4[24] SWTST_u32CalibTst4[25] SWTST_u32CalibTst4[26] SWTST_u32CalibTst4[27] SWTST_u32CalibTst4[28] SWTST_u32CalibTst4[29] SWTST_u32CalibTst4[2] SWTST_u32CalibTst4[30] SWTST_u32CalibTst4[31] SWTST_u32CalibTst4[32] SWTST_u32CalibTst4[33] SWTST_u32CalibTst4[34] SWTST_u32CalibTst4[35] SWTST_u32CalibTst4[36] SWTST_u32CalibTst4[37] SWTST_u32CalibTst4[38] SWTST_u32CalibTst4[39] SWTST_u32CalibTst4[3] SWTST_u32CalibTst4[40] SWTST_u32CalibTst4[41] SWTST_u32CalibTst4[42] SWTST_u32CalibTst4[43] SWTST_u32CalibTst4[44] SWTST_u32CalibTst4[45] SWTST_u32CalibTst4[46] SWTST_u32CalibTst4[47] SWTST_u32CalibTst4[48] SWTST_u32CalibTst4[49] SWTST_u32CalibTst4[4] SWTST_u32CalibTst4[50] SWTST_u32CalibTst4[51] SWTST_u32CalibTst4[52] SWTST_u32CalibTst4[53] SWTST_u32CalibTst4[54] SWTST_u32CalibTst4[55] SWTST_u32CalibTst4[56] SWTST_u32CalibTst4[57] SWTST_u32CalibTst4[58] SWTST_u32CalibTst4[59] SWTST_u32CalibTst4[5] SWTST_u32CalibTst4[60] SWTST_u32CalibTst4[61] SWTST_u32CalibTst4[62] SWTST_u32CalibTst4[63] SWTST_u32CalibTst4[64] SWTST_u32CalibTst4[65] SWTST_u32CalibTst4[66] SWTST_u32CalibTst4[67] SWTST_u32CalibTst4[68] SWTST_u32CalibTst4[69] SWTST_u32CalibTst4[6] SWTST_u32CalibTst4[70] SWTST_u32CalibTst4[71] SWTST_u32CalibTst4[72] SWTST_u32CalibTst4[73] SWTST_u32CalibTst4[74] SWTST_u32CalibTst4[75] SWTST_u32CalibTst4[76] SWTST_u32CalibTst4[77] SWTST_u32CalibTst4[78] SWTST_u32CalibTst4[79] SWTST_u32CalibTst4[7] SWTST_u32CalibTst4[80] SWTST_u32CalibTst4[81] SWTST_u32CalibTst4[82] SWTST_u32CalibTst4[83] SWTST_u32CalibTst4[84] SWTST_u32CalibTst4[85] SWTST_u32CalibTst4[86] SWTST_u32CalibTst4[87] SWTST_u32CalibTst4[88] SWTST_u32CalibTst4[89] SWTST_u32CalibTst4[8] SWTST_u32CalibTst4[90] SWTST_u32CalibTst4[91] SWTST_u32CalibTst4[92] SWTST_u32CalibTst4[93] SWTST_u32CalibTst4[94] SWTST_u32CalibTst4[95] SWTST_u32CalibTst4[96] SWTST_u32CalibTst4[97] SWTST_u32CalibTst4[98] SWTST_u32CalibTst4[99] SWTST_u32CalibTst4[9] SWTST_u32CalibTst5 SWTST_u32CalibTst5[0] SWTST_u32CalibTst5[10] SWTST_u32CalibTst5[11] SWTST_u32CalibTst5[12] SWTST_u32CalibTst5[13] SWTST_u32CalibTst5[14] SWTST_u32CalibTst5[15] SWTST_u32CalibTst5[16] SWTST_u32CalibTst5[17] SWTST_u32CalibTst5[18] SWTST_u32CalibTst5[19] SWTST_u32CalibTst5[1] SWTST_u32CalibTst5[20] SWTST_u32CalibTst5[21] SWTST_u32CalibTst5[22] SWTST_u32CalibTst5[23] SWTST_u32CalibTst5[24] SWTST_u32CalibTst5[25] SWTST_u32CalibTst5[26] SWTST_u32CalibTst5[27] SWTST_u32CalibTst5[28] SWTST_u32CalibTst5[29] SWTST_u32CalibTst5[2] SWTST_u32CalibTst5[30] SWTST_u32CalibTst5[31] SWTST_u32CalibTst5[32] SWTST_u32CalibTst5[33] SWTST_u32CalibTst5[34] SWTST_u32CalibTst5[35] SWTST_u32CalibTst5[36] SWTST_u32CalibTst5[37] SWTST_u32CalibTst5[38] SWTST_u32CalibTst5[39] SWTST_u32CalibTst5[3] SWTST_u32CalibTst5[40] SWTST_u32CalibTst5[41] SWTST_u32CalibTst5[42] SWTST_u32CalibTst5[43] SWTST_u32CalibTst5[44] SWTST_u32CalibTst5[45] SWTST_u32CalibTst5[46] SWTST_u32CalibTst5[47] SWTST_u32CalibTst5[48] SWTST_u32CalibTst5[49] SWTST_u32CalibTst5[4] SWTST_u32CalibTst5[50] SWTST_u32CalibTst5[51] SWTST_u32CalibTst5[52] SWTST_u32CalibTst5[53] SWTST_u32CalibTst5[54] SWTST_u32CalibTst5[55] SWTST_u32CalibTst5[56] SWTST_u32CalibTst5[57] SWTST_u32CalibTst5[58] SWTST_u32CalibTst5[59] SWTST_u32CalibTst5[5] SWTST_u32CalibTst5[60] SWTST_u32CalibTst5[61] SWTST_u32CalibTst5[62] SWTST_u32CalibTst5[63] SWTST_u32CalibTst5[64] SWTST_u32CalibTst5[65] SWTST_u32CalibTst5[66] SWTST_u32CalibTst5[67] SWTST_u32CalibTst5[68] SWTST_u32CalibTst5[69] SWTST_u32CalibTst5[6] SWTST_u32CalibTst5[70] SWTST_u32CalibTst5[71] SWTST_u32CalibTst5[72] SWTST_u32CalibTst5[73] SWTST_u32CalibTst5[74] SWTST_u32CalibTst5[75] SWTST_u32CalibTst5[76] SWTST_u32CalibTst5[77] SWTST_u32CalibTst5[78] SWTST_u32CalibTst5[79] SWTST_u32CalibTst5[7] SWTST_u32CalibTst5[80] SWTST_u32CalibTst5[81] SWTST_u32CalibTst5[82] SWTST_u32CalibTst5[83] SWTST_u32CalibTst5[84] SWTST_u32CalibTst5[85] SWTST_u32CalibTst5[86] SWTST_u32CalibTst5[87] SWTST_u32CalibTst5[88] SWTST_u32CalibTst5[89] SWTST_u32CalibTst5[8] SWTST_u32CalibTst5[90] SWTST_u32CalibTst5[91] SWTST_u32CalibTst5[92] SWTST_u32CalibTst5[93] SWTST_u32CalibTst5[94] SWTST_u32CalibTst5[95] SWTST_u32CalibTst5[96] SWTST_u32CalibTst5[97] SWTST_u32CalibTst5[98] SWTST_u32CalibTst5[99] SWTST_u32CalibTst5[9] SWTST_u32CalibTst6 SWTST_u32CalibTst6[0] SWTST_u32CalibTst6[10] SWTST_u32CalibTst6[11] SWTST_u32CalibTst6[12] SWTST_u32CalibTst6[13] SWTST_u32CalibTst6[14] SWTST_u32CalibTst6[15] SWTST_u32CalibTst6[16] SWTST_u32CalibTst6[17] SWTST_u32CalibTst6[18] SWTST_u32CalibTst6[19] SWTST_u32CalibTst6[1] SWTST_u32CalibTst6[20] SWTST_u32CalibTst6[21] SWTST_u32CalibTst6[22] SWTST_u32CalibTst6[23] SWTST_u32CalibTst6[24] SWTST_u32CalibTst6[25] SWTST_u32CalibTst6[26] SWTST_u32CalibTst6[27] SWTST_u32CalibTst6[28] SWTST_u32CalibTst6[29] SWTST_u32CalibTst6[2] SWTST_u32CalibTst6[30] SWTST_u32CalibTst6[31] SWTST_u32CalibTst6[32] SWTST_u32CalibTst6[33] SWTST_u32CalibTst6[34] SWTST_u32CalibTst6[35] SWTST_u32CalibTst6[36] SWTST_u32CalibTst6[37] SWTST_u32CalibTst6[38] SWTST_u32CalibTst6[39] SWTST_u32CalibTst6[3] SWTST_u32CalibTst6[40] SWTST_u32CalibTst6[41] SWTST_u32CalibTst6[42] SWTST_u32CalibTst6[43] SWTST_u32CalibTst6[44] SWTST_u32CalibTst6[45] SWTST_u32CalibTst6[46] SWTST_u32CalibTst6[47] SWTST_u32CalibTst6[48] SWTST_u32CalibTst6[49] SWTST_u32CalibTst6[4] SWTST_u32CalibTst6[50] SWTST_u32CalibTst6[51] SWTST_u32CalibTst6[52] SWTST_u32CalibTst6[53] SWTST_u32CalibTst6[54] SWTST_u32CalibTst6[55] SWTST_u32CalibTst6[56] SWTST_u32CalibTst6[57] SWTST_u32CalibTst6[58] SWTST_u32CalibTst6[59] SWTST_u32CalibTst6[5] SWTST_u32CalibTst6[60] SWTST_u32CalibTst6[61] SWTST_u32CalibTst6[62] SWTST_u32CalibTst6[63] SWTST_u32CalibTst6[64] SWTST_u32CalibTst6[65] SWTST_u32CalibTst6[66] SWTST_u32CalibTst6[67] SWTST_u32CalibTst6[68] SWTST_u32CalibTst6[69] SWTST_u32CalibTst6[6] SWTST_u32CalibTst6[70] SWTST_u32CalibTst6[71] SWTST_u32CalibTst6[72] SWTST_u32CalibTst6[73] SWTST_u32CalibTst6[74] SWTST_u32CalibTst6[75] SWTST_u32CalibTst6[76] SWTST_u32CalibTst6[77] SWTST_u32CalibTst6[78] SWTST_u32CalibTst6[79] SWTST_u32CalibTst6[7] SWTST_u32CalibTst6[80] SWTST_u32CalibTst6[81] SWTST_u32CalibTst6[82] SWTST_u32CalibTst6[83] SWTST_u32CalibTst6[84] SWTST_u32CalibTst6[85] SWTST_u32CalibTst6[86] SWTST_u32CalibTst6[87] SWTST_u32CalibTst6[88] SWTST_u32CalibTst6[89] SWTST_u32CalibTst6[8] SWTST_u32CalibTst6[90] SWTST_u32CalibTst6[91] SWTST_u32CalibTst6[92] SWTST_u32CalibTst6[93] SWTST_u32CalibTst6[94] SWTST_u32CalibTst6[95] SWTST_u32CalibTst6[96] SWTST_u32CalibTst6[97] SWTST_u32CalibTst6[98] SWTST_u32CalibTst6[99] SWTST_u32CalibTst6[9] SWTST_u32CalibTst7 SWTST_u32CalibTst7[0] SWTST_u32CalibTst7[10] SWTST_u32CalibTst7[11] SWTST_u32CalibTst7[12] SWTST_u32CalibTst7[13] SWTST_u32CalibTst7[14] SWTST_u32CalibTst7[15] SWTST_u32CalibTst7[16] SWTST_u32CalibTst7[17] SWTST_u32CalibTst7[18] SWTST_u32CalibTst7[19] SWTST_u32CalibTst7[1] SWTST_u32CalibTst7[20] SWTST_u32CalibTst7[21] SWTST_u32CalibTst7[22] SWTST_u32CalibTst7[23] SWTST_u32CalibTst7[24] SWTST_u32CalibTst7[25] SWTST_u32CalibTst7[26] SWTST_u32CalibTst7[27] SWTST_u32CalibTst7[28] SWTST_u32CalibTst7[29] SWTST_u32CalibTst7[2] SWTST_u32CalibTst7[30] SWTST_u32CalibTst7[31] SWTST_u32CalibTst7[32] SWTST_u32CalibTst7[33] SWTST_u32CalibTst7[34] SWTST_u32CalibTst7[35] SWTST_u32CalibTst7[36] SWTST_u32CalibTst7[37] SWTST_u32CalibTst7[38] SWTST_u32CalibTst7[39] SWTST_u32CalibTst7[3] SWTST_u32CalibTst7[40] SWTST_u32CalibTst7[41] SWTST_u32CalibTst7[42] SWTST_u32CalibTst7[43] SWTST_u32CalibTst7[44] SWTST_u32CalibTst7[45] SWTST_u32CalibTst7[46] SWTST_u32CalibTst7[47] SWTST_u32CalibTst7[48] SWTST_u32CalibTst7[49] SWTST_u32CalibTst7[4] SWTST_u32CalibTst7[50] SWTST_u32CalibTst7[51] SWTST_u32CalibTst7[52] SWTST_u32CalibTst7[53] SWTST_u32CalibTst7[54] SWTST_u32CalibTst7[55] SWTST_u32CalibTst7[56] SWTST_u32CalibTst7[57] SWTST_u32CalibTst7[58] SWTST_u32CalibTst7[59] SWTST_u32CalibTst7[5] SWTST_u32CalibTst7[60] SWTST_u32CalibTst7[61] SWTST_u32CalibTst7[62] SWTST_u32CalibTst7[63] SWTST_u32CalibTst7[64] SWTST_u32CalibTst7[65] SWTST_u32CalibTst7[66] SWTST_u32CalibTst7[67] SWTST_u32CalibTst7[68] SWTST_u32CalibTst7[69] SWTST_u32CalibTst7[6] SWTST_u32CalibTst7[70] SWTST_u32CalibTst7[71] SWTST_u32CalibTst7[72] SWTST_u32CalibTst7[73] SWTST_u32CalibTst7[74] SWTST_u32CalibTst7[75] SWTST_u32CalibTst7[76] SWTST_u32CalibTst7[77] SWTST_u32CalibTst7[78] SWTST_u32CalibTst7[79] SWTST_u32CalibTst7[7] SWTST_u32CalibTst7[80] SWTST_u32CalibTst7[81] SWTST_u32CalibTst7[82] SWTST_u32CalibTst7[83] SWTST_u32CalibTst7[84] SWTST_u32CalibTst7[85] SWTST_u32CalibTst7[86] SWTST_u32CalibTst7[87] SWTST_u32CalibTst7[88] SWTST_u32CalibTst7[89] SWTST_u32CalibTst7[8] SWTST_u32CalibTst7[90] SWTST_u32CalibTst7[91] SWTST_u32CalibTst7[92] SWTST_u32CalibTst7[93] SWTST_u32CalibTst7[94] SWTST_u32CalibTst7[95] SWTST_u32CalibTst7[96] SWTST_u32CalibTst7[97] SWTST_u32CalibTst7[98] SWTST_u32CalibTst7[99] SWTST_u32CalibTst7[9] SWTST_u32CalibTst8 SWTST_u32CalibTst8[0] SWTST_u32CalibTst8[10] SWTST_u32CalibTst8[11] SWTST_u32CalibTst8[12] SWTST_u32CalibTst8[13] SWTST_u32CalibTst8[14] SWTST_u32CalibTst8[15] SWTST_u32CalibTst8[16] SWTST_u32CalibTst8[17] SWTST_u32CalibTst8[18] SWTST_u32CalibTst8[19] SWTST_u32CalibTst8[1] SWTST_u32CalibTst8[20] SWTST_u32CalibTst8[21] SWTST_u32CalibTst8[22] SWTST_u32CalibTst8[23] SWTST_u32CalibTst8[24] SWTST_u32CalibTst8[25] SWTST_u32CalibTst8[26] SWTST_u32CalibTst8[27] SWTST_u32CalibTst8[28] SWTST_u32CalibTst8[29] SWTST_u32CalibTst8[2] SWTST_u32CalibTst8[30] SWTST_u32CalibTst8[31] SWTST_u32CalibTst8[32] SWTST_u32CalibTst8[33] SWTST_u32CalibTst8[34] SWTST_u32CalibTst8[35] SWTST_u32CalibTst8[36] SWTST_u32CalibTst8[37] SWTST_u32CalibTst8[38] SWTST_u32CalibTst8[39] SWTST_u32CalibTst8[3] SWTST_u32CalibTst8[40] SWTST_u32CalibTst8[41] SWTST_u32CalibTst8[42] SWTST_u32CalibTst8[43] SWTST_u32CalibTst8[44] SWTST_u32CalibTst8[45] SWTST_u32CalibTst8[46] SWTST_u32CalibTst8[47] SWTST_u32CalibTst8[48] SWTST_u32CalibTst8[49] SWTST_u32CalibTst8[4] SWTST_u32CalibTst8[50] SWTST_u32CalibTst8[51] SWTST_u32CalibTst8[52] SWTST_u32CalibTst8[53] SWTST_u32CalibTst8[54] SWTST_u32CalibTst8[55] SWTST_u32CalibTst8[56] SWTST_u32CalibTst8[57] SWTST_u32CalibTst8[58] SWTST_u32CalibTst8[59] SWTST_u32CalibTst8[5] SWTST_u32CalibTst8[60] SWTST_u32CalibTst8[61] SWTST_u32CalibTst8[62] SWTST_u32CalibTst8[63] SWTST_u32CalibTst8[64] SWTST_u32CalibTst8[65] SWTST_u32CalibTst8[66] SWTST_u32CalibTst8[67] SWTST_u32CalibTst8[68] SWTST_u32CalibTst8[69] SWTST_u32CalibTst8[6] SWTST_u32CalibTst8[70] SWTST_u32CalibTst8[71] SWTST_u32CalibTst8[72] SWTST_u32CalibTst8[73] SWTST_u32CalibTst8[74] SWTST_u32CalibTst8[75] SWTST_u32CalibTst8[76] SWTST_u32CalibTst8[77] SWTST_u32CalibTst8[78] SWTST_u32CalibTst8[79] SWTST_u32CalibTst8[7] SWTST_u32CalibTst8[80] SWTST_u32CalibTst8[81] SWTST_u32CalibTst8[82] SWTST_u32CalibTst8[83] SWTST_u32CalibTst8[84] SWTST_u32CalibTst8[85] SWTST_u32CalibTst8[86] SWTST_u32CalibTst8[87] SWTST_u32CalibTst8[88] SWTST_u32CalibTst8[89] SWTST_u32CalibTst8[8] SWTST_u32CalibTst8[90] SWTST_u32CalibTst8[91] SWTST_u32CalibTst8[92] SWTST_u32CalibTst8[93] SWTST_u32CalibTst8[94] SWTST_u32CalibTst8[95] SWTST_u32CalibTst8[96] SWTST_u32CalibTst8[97] SWTST_u32CalibTst8[98] SWTST_u32CalibTst8[99] SWTST_u32CalibTst8[9] SWTST_u32CalibTst9 SWTST_u32CalibTst9[0] SWTST_u32CalibTst9[10] SWTST_u32CalibTst9[11] SWTST_u32CalibTst9[12] SWTST_u32CalibTst9[13] SWTST_u32CalibTst9[14] SWTST_u32CalibTst9[15] SWTST_u32CalibTst9[16] SWTST_u32CalibTst9[17] SWTST_u32CalibTst9[18] SWTST_u32CalibTst9[19] SWTST_u32CalibTst9[1] SWTST_u32CalibTst9[20] SWTST_u32CalibTst9[21] SWTST_u32CalibTst9[22] SWTST_u32CalibTst9[23] SWTST_u32CalibTst9[24] SWTST_u32CalibTst9[25] SWTST_u32CalibTst9[26] SWTST_u32CalibTst9[27] SWTST_u32CalibTst9[28] SWTST_u32CalibTst9[29] SWTST_u32CalibTst9[2] SWTST_u32CalibTst9[30] SWTST_u32CalibTst9[31] SWTST_u32CalibTst9[32] SWTST_u32CalibTst9[33] SWTST_u32CalibTst9[34] SWTST_u32CalibTst9[35] SWTST_u32CalibTst9[36] SWTST_u32CalibTst9[37] SWTST_u32CalibTst9[38] SWTST_u32CalibTst9[39] SWTST_u32CalibTst9[3] SWTST_u32CalibTst9[40] SWTST_u32CalibTst9[41] SWTST_u32CalibTst9[42] SWTST_u32CalibTst9[43] SWTST_u32CalibTst9[44] SWTST_u32CalibTst9[45] SWTST_u32CalibTst9[46] SWTST_u32CalibTst9[47] SWTST_u32CalibTst9[48] SWTST_u32CalibTst9[49] SWTST_u32CalibTst9[4] SWTST_u32CalibTst9[50] SWTST_u32CalibTst9[51] SWTST_u32CalibTst9[52] SWTST_u32CalibTst9[53] SWTST_u32CalibTst9[54] SWTST_u32CalibTst9[55] SWTST_u32CalibTst9[56] SWTST_u32CalibTst9[57] SWTST_u32CalibTst9[58] SWTST_u32CalibTst9[59] SWTST_u32CalibTst9[5] SWTST_u32CalibTst9[60] SWTST_u32CalibTst9[61] SWTST_u32CalibTst9[62] SWTST_u32CalibTst9[63] SWTST_u32CalibTst9[64] SWTST_u32CalibTst9[65] SWTST_u32CalibTst9[66] SWTST_u32CalibTst9[67] SWTST_u32CalibTst9[68] SWTST_u32CalibTst9[69] SWTST_u32CalibTst9[6] SWTST_u32CalibTst9[70] SWTST_u32CalibTst9[71] SWTST_u32CalibTst9[72] SWTST_u32CalibTst9[73] SWTST_u32CalibTst9[74] SWTST_u32CalibTst9[75] SWTST_u32CalibTst9[76] SWTST_u32CalibTst9[77] SWTST_u32CalibTst9[78] SWTST_u32CalibTst9[79] SWTST_u32CalibTst9[7] SWTST_u32CalibTst9[80] SWTST_u32CalibTst9[81] SWTST_u32CalibTst9[82] SWTST_u32CalibTst9[83] SWTST_u32CalibTst9[84] SWTST_u32CalibTst9[85] SWTST_u32CalibTst9[86] SWTST_u32CalibTst9[87] SWTST_u32CalibTst9[88] SWTST_u32CalibTst9[89] SWTST_u32CalibTst9[8] SWTST_u32CalibTst9[90] SWTST_u32CalibTst9[91] SWTST_u32CalibTst9[92] SWTST_u32CalibTst9[93] SWTST_u32CalibTst9[94] SWTST_u32CalibTst9[95] SWTST_u32CalibTst9[96] SWTST_u32CalibTst9[97] SWTST_u32CalibTst9[98] SWTST_u32CalibTst9[99] SWTST_u32CalibTst9[9] SWTST_u32ComTstErrInfo SWTST_u32DioTstErrInfo SWTST_u32EVPTstErrInfo SWTST_u32Lvl2RamCrcTstInitGlbLvl2TstVar SWTST_u32Lvl2RamCrcTstLvl2GlbVar SWTST_u32Lvl2RamCrcTstPwrOnClrGlbLvl2TstVar SWTST_u32Lvl2RamCrcTstPwrOnInitGlbLvl2TstVar SWTST_u32SftyPreSafeStsCntr SWTST_u32Tle62X0TstErrInfo SWTST_u8AdcResumeTstNr SWTST_u8AdcTstDoneNr SWTST_u8AdcTstErrId SWTST_u8AdcTstNrNm1 SWTST_u8Btt6020ResumeTstNr SWTST_u8Btt6020TstDoneNr SWTST_u8Btt6020TstErrId SWTST_u8Btt6020TstNrNm1 SWTST_u8CalibResumeTstNr SWTST_u8CalibTstDoneNr SWTST_u8CalibTstErrId SWTST_u8CalibTstNrNm1 SWTST_u8ComRdCcvs1Sa00BrakeSwitch SWTST_u8ComRdCcvs1Sa00ClutchSwitch SWTST_u8ComRdCcvs1Sa00CruiseCtrlAccelerateSwitch SWTST_u8ComRdCcvs1Sa00CruiseCtrlActive SWTST_u8ComRdCcvs1Sa00CruiseCtrlCoastSwitch SWTST_u8ComRdCcvs1Sa00CruiseCtrlEnableSwitch SWTST_u8ComRdCcvs1Sa00CruiseCtrlPauseSwitch SWTST_u8ComRdCcvs1Sa00CruiseCtrlResumeSwitch SWTST_u8ComRdCcvs1Sa00CruiseCtrlSetSwitch SWTST_u8ComRdCcvs1Sa00CruiseCtrlStates SWTST_u8ComRdCcvs1Sa00EngIdleDecrementSwitch SWTST_u8ComRdCcvs1Sa00EngIdleIncrementSwitch SWTST_u8ComRdCcvs1Sa00EngShutdownOverrideSwitch SWTST_u8ComRdCcvs1Sa00EngTestModeSwitch SWTST_u8ComRdCcvs1Sa00ParkBrakeReleaseInhibitRq SWTST_u8ComRdCcvs1Sa00ParkingBrakeSwitch SWTST_u8ComRdCcvs1Sa00PTOGovernorState SWTST_u8ComRdCcvs1Sa00TwoSpeedAxleSwitch SWTST_u8ComRdCcvs1Sa17BrakeSwitch SWTST_u8ComRdCcvs1Sa17ClutchSwitch SWTST_u8ComRdCcvs1Sa17CruiseCtrlAccelerateSwitch SWTST_u8ComRdCcvs1Sa17CruiseCtrlActive SWTST_u8ComRdCcvs1Sa17CruiseCtrlCoastSwitch SWTST_u8ComRdCcvs1Sa17CruiseCtrlEnableSwitch SWTST_u8ComRdCcvs1Sa17CruiseCtrlPauseSwitch SWTST_u8ComRdCcvs1Sa17CruiseCtrlResumeSwitch SWTST_u8ComRdCcvs1Sa17CruiseCtrlSetSwitch SWTST_u8ComRdCcvs1Sa17CruiseCtrlStates SWTST_u8ComRdCcvs1Sa17EngIdleDecrementSwitch SWTST_u8ComRdCcvs1Sa17EngIdleIncrementSwitch SWTST_u8ComRdCcvs1Sa17EngShutdownOverrideSwitch SWTST_u8ComRdCcvs1Sa17EngTestModeSwitch SWTST_u8ComRdCcvs1Sa17ParkBrakeReleaseInhibitRq SWTST_u8ComRdCcvs1Sa17ParkingBrakeSwitch SWTST_u8ComRdCcvs1Sa17PTOGovernorState SWTST_u8ComRdCcvs1Sa17TwoSpeedAxleSwitch SWTST_u8ComRdCcvs1Sa232BrakeSwitch SWTST_u8ComRdCcvs1Sa232ClutchSwitch SWTST_u8ComRdCcvs1Sa232CruiseCtrlAccelerateSwitch SWTST_u8ComRdCcvs1Sa232CruiseCtrlActive SWTST_u8ComRdCcvs1Sa232CruiseCtrlCoastSwitch SWTST_u8ComRdCcvs1Sa232CruiseCtrlEnableSwitch SWTST_u8ComRdCcvs1Sa232CruiseCtrlPauseSwitch SWTST_u8ComRdCcvs1Sa232CruiseCtrlResumeSwitch SWTST_u8ComRdCcvs1Sa232CruiseCtrlSetSwitch SWTST_u8ComRdCcvs1Sa232CruiseCtrlStates SWTST_u8ComRdCcvs1Sa232EngIdleDecrementSwitch SWTST_u8ComRdCcvs1Sa232EngIdleIncrementSwitch SWTST_u8ComRdCcvs1Sa232EngShutdownOverrideSwitch SWTST_u8ComRdCcvs1Sa232EngTestModeSwitch SWTST_u8ComRdCcvs1Sa232ParkBrakeReleaseInhibitRq SWTST_u8ComRdCcvs1Sa232ParkingBrakeSwitch SWTST_u8ComRdCcvs1Sa232PTOGovernorState SWTST_u8ComRdCcvs1Sa232TwoSpeedAxleSwitch SWTST_u8ComRdCcvs1Sa23BrakeSwitch SWTST_u8ComRdCcvs1Sa23ClutchSwitch SWTST_u8ComRdCcvs1Sa23CruiseCtrlAccelerateSwitch SWTST_u8ComRdCcvs1Sa23CruiseCtrlActive SWTST_u8ComRdCcvs1Sa23CruiseCtrlCoastSwitch SWTST_u8ComRdCcvs1Sa23CruiseCtrlEnableSwitch SWTST_u8ComRdCcvs1Sa23CruiseCtrlPauseSwitch SWTST_u8ComRdCcvs1Sa23CruiseCtrlResumeSwitch SWTST_u8ComRdCcvs1Sa23CruiseCtrlSetSwitch SWTST_u8ComRdCcvs1Sa23CruiseCtrlStates SWTST_u8ComRdCcvs1Sa23EngIdleDecrementSwitch SWTST_u8ComRdCcvs1Sa23EngIdleIncrementSwitch SWTST_u8ComRdCcvs1Sa23EngShutdownOverrideSwitch SWTST_u8ComRdCcvs1Sa23EngTestModeSwitch SWTST_u8ComRdCcvs1Sa23ParkBrakeReleaseInhibitRq SWTST_u8ComRdCcvs1Sa23ParkingBrakeSwitch SWTST_u8ComRdCcvs1Sa23PTOGovernorState SWTST_u8ComRdCcvs1Sa23TwoSpeedAxleSwitch SWTST_u8ComRdCcvs1Sa33BrakeSwitch SWTST_u8ComRdCcvs1Sa33ClutchSwitch SWTST_u8ComRdCcvs1Sa33CruiseCtrlAccelerateSwitch SWTST_u8ComRdCcvs1Sa33CruiseCtrlActive SWTST_u8ComRdCcvs1Sa33CruiseCtrlCoastSwitch SWTST_u8ComRdCcvs1Sa33CruiseCtrlEnableSwitch SWTST_u8ComRdCcvs1Sa33CruiseCtrlPauseSwitch SWTST_u8ComRdCcvs1Sa33CruiseCtrlResumeSwitch SWTST_u8ComRdCcvs1Sa33CruiseCtrlSetSwitch SWTST_u8ComRdCcvs1Sa33CruiseCtrlStates SWTST_u8ComRdCcvs1Sa33EngIdleDecrementSwitch SWTST_u8ComRdCcvs1Sa33EngIdleIncrementSwitch SWTST_u8ComRdCcvs1Sa33EngShutdownOverrideSwitch SWTST_u8ComRdCcvs1Sa33EngTestModeSwitch SWTST_u8ComRdCcvs1Sa33ParkBrakeReleaseInhibitRq SWTST_u8ComRdCcvs1Sa33ParkingBrakeSwitch SWTST_u8ComRdCcvs1Sa33PTOGovernorState SWTST_u8ComRdCcvs1Sa33TwoSpeedAxleSwitch SWTST_u8ComRdCcvs1Sa39BrakeSwitch SWTST_u8ComRdCcvs1Sa39ClutchSwitch SWTST_u8ComRdCcvs1Sa39CruiseCtrlAccelerateSwitch SWTST_u8ComRdCcvs1Sa39CruiseCtrlActive SWTST_u8ComRdCcvs1Sa39CruiseCtrlCoastSwitch SWTST_u8ComRdCcvs1Sa39CruiseCtrlEnableSwitch SWTST_u8ComRdCcvs1Sa39CruiseCtrlPauseSwitch SWTST_u8ComRdCcvs1Sa39CruiseCtrlResumeSwitch SWTST_u8ComRdCcvs1Sa39CruiseCtrlSetSwitch SWTST_u8ComRdCcvs1Sa39CruiseCtrlStates SWTST_u8ComRdCcvs1Sa39EngIdleDecrementSwitch SWTST_u8ComRdCcvs1Sa39EngIdleIncrementSwitch SWTST_u8ComRdCcvs1Sa39EngShutdownOverrideSwitch SWTST_u8ComRdCcvs1Sa39EngTestModeSwitch SWTST_u8ComRdCcvs1Sa39ParkBrakeReleaseInhibitRq SWTST_u8ComRdCcvs1Sa39ParkingBrakeSwitch SWTST_u8ComRdCcvs1Sa39PTOGovernorState SWTST_u8ComRdCcvs1Sa39TwoSpeedAxleSwitch SWTST_u8ComRdCcvs1Sa49BrakeSwitch SWTST_u8ComRdCcvs1Sa49ClutchSwitch SWTST_u8ComRdCcvs1Sa49CruiseCtrlAccelerateSwitch SWTST_u8ComRdCcvs1Sa49CruiseCtrlActive SWTST_u8ComRdCcvs1Sa49CruiseCtrlCoastSwitch SWTST_u8ComRdCcvs1Sa49CruiseCtrlEnableSwitch SWTST_u8ComRdCcvs1Sa49CruiseCtrlPauseSwitch SWTST_u8ComRdCcvs1Sa49CruiseCtrlResumeSwitch SWTST_u8ComRdCcvs1Sa49CruiseCtrlSetSwitch SWTST_u8ComRdCcvs1Sa49CruiseCtrlStates SWTST_u8ComRdCcvs1Sa49EngIdleDecrementSwitch SWTST_u8ComRdCcvs1Sa49EngIdleIncrementSwitch SWTST_u8ComRdCcvs1Sa49EngShutdownOverrideSwitch SWTST_u8ComRdCcvs1Sa49EngTestModeSwitch SWTST_u8ComRdCcvs1Sa49ParkBrakeReleaseInhibitRq SWTST_u8ComRdCcvs1Sa49ParkingBrakeSwitch SWTST_u8ComRdCcvs1Sa49PTOGovernorState SWTST_u8ComRdCcvs1Sa49TwoSpeedAxleSwitch SWTST_u8ComRdEbc1Sa00ABSEBSAmberWarningSignal SWTST_u8ComRdEbc1Sa00ABSFullyOperational SWTST_u8ComRdEbc1Sa00ABSOffroadSwitch SWTST_u8ComRdEbc1Sa00AccelInterlockSwitch SWTST_u8ComRdEbc1Sa00AntiLockBrakingActive SWTST_u8ComRdEbc1Sa00ASRBrakeCtrlActive SWTST_u8ComRdEbc1Sa00ASREngCtrlActive SWTST_u8ComRdEbc1Sa00ASRHillHolderSwitch SWTST_u8ComRdEbc1Sa00ASROffroadSwitch SWTST_u8ComRdEbc1Sa00ATCASRInformationSignal SWTST_u8ComRdEbc1Sa00EBSBrakeSwitch SWTST_u8ComRdEbc1Sa00EBSRedWarningSignal SWTST_u8ComRdEbc1Sa00EngAuxShutdownSwitch SWTST_u8ComRdEbc1Sa00EngDerateSwitch SWTST_u8ComRdEbc1Sa00HaltBrakeSwitch SWTST_u8ComRdEbc1Sa00RemoteAccelEnableSwitch SWTST_u8ComRdEbc1Sa00SrcAddrssOfCntrllngDvcFrBrkeCtrl SWTST_u8ComRdEbc1Sa00TractionCtrlOverrideSwitch SWTST_u8ComRdEbc1Sa00TrailerABSStatus SWTST_u8ComRdEbc1Sa00TrctrMntdTrailerABSWarningSignal SWTST_u8ComRdEbc1Sa11ABSEBSAmberWarningSignal SWTST_u8ComRdEbc1Sa11ABSFullyOperational SWTST_u8ComRdEbc1Sa11ABSOffroadSwitch SWTST_u8ComRdEbc1Sa11AccelInterlockSwitch SWTST_u8ComRdEbc1Sa11AntiLockBrakingActive SWTST_u8ComRdEbc1Sa11ASRBrakeCtrlActive SWTST_u8ComRdEbc1Sa11ASREngCtrlActive SWTST_u8ComRdEbc1Sa11ASRHillHolderSwitch SWTST_u8ComRdEbc1Sa11ASROffroadSwitch SWTST_u8ComRdEbc1Sa11ATCASRInformationSignal SWTST_u8ComRdEbc1Sa11EBSBrakeSwitch SWTST_u8ComRdEbc1Sa11EBSRedWarningSignal SWTST_u8ComRdEbc1Sa11EngAuxShutdownSwitch SWTST_u8ComRdEbc1Sa11EngDerateSwitch SWTST_u8ComRdEbc1Sa11HaltBrakeSwitch SWTST_u8ComRdEbc1Sa11RemoteAccelEnableSwitch SWTST_u8ComRdEbc1Sa11SrcAddrssOfCntrllngDvcFrBrkeCtrl SWTST_u8ComRdEbc1Sa11TractionCtrlOverrideSwitch SWTST_u8ComRdEbc1Sa11TrailerABSStatus SWTST_u8ComRdEbc1Sa11TrctrMntdTrailerABSWarningSignal SWTST_u8ComRdEbc1Sa23ABSEBSAmberWarningSignal SWTST_u8ComRdEbc1Sa23ABSFullyOperational SWTST_u8ComRdEbc1Sa23ABSOffroadSwitch SWTST_u8ComRdEbc1Sa23AccelInterlockSwitch SWTST_u8ComRdEbc1Sa23AntiLockBrakingActive SWTST_u8ComRdEbc1Sa23ASRBrakeCtrlActive SWTST_u8ComRdEbc1Sa23ASREngCtrlActive SWTST_u8ComRdEbc1Sa23ASRHillHolderSwitch SWTST_u8ComRdEbc1Sa23ASROffroadSwitch SWTST_u8ComRdEbc1Sa23ATCASRInformationSignal SWTST_u8ComRdEbc1Sa23EBSBrakeSwitch SWTST_u8ComRdEbc1Sa23EBSRedWarningSignal SWTST_u8ComRdEbc1Sa23EngAuxShutdownSwitch SWTST_u8ComRdEbc1Sa23EngDerateSwitch SWTST_u8ComRdEbc1Sa23HaltBrakeSwitch SWTST_u8ComRdEbc1Sa23RemoteAccelEnableSwitch SWTST_u8ComRdEbc1Sa23SrcAddrssOfCntrllngDvcFrBrkeCtrl SWTST_u8ComRdEbc1Sa23TractionCtrlOverrideSwitch SWTST_u8ComRdEbc1Sa23TrailerABSStatus SWTST_u8ComRdEbc1Sa23TrctrMntdTrailerABSWarningSignal SWTST_u8ComRdEbc1Sa33ABSEBSAmberWarningSignal SWTST_u8ComRdEbc1Sa33ABSFullyOperational SWTST_u8ComRdEbc1Sa33ABSOffroadSwitch SWTST_u8ComRdEbc1Sa33AccelInterlockSwitch SWTST_u8ComRdEbc1Sa33AntiLockBrakingActive SWTST_u8ComRdEbc1Sa33ASRBrakeCtrlActive SWTST_u8ComRdEbc1Sa33ASREngCtrlActive SWTST_u8ComRdEbc1Sa33ASRHillHolderSwitch SWTST_u8ComRdEbc1Sa33ASROffroadSwitch SWTST_u8ComRdEbc1Sa33ATCASRInformationSignal SWTST_u8ComRdEbc1Sa33EBSBrakeSwitch SWTST_u8ComRdEbc1Sa33EBSRedWarningSignal SWTST_u8ComRdEbc1Sa33EngAuxShutdownSwitch SWTST_u8ComRdEbc1Sa33EngDerateSwitch SWTST_u8ComRdEbc1Sa33HaltBrakeSwitch SWTST_u8ComRdEbc1Sa33RemoteAccelEnableSwitch SWTST_u8ComRdEbc1Sa33SrcAddrssOfCntrllngDvcFrBrkeCtrl SWTST_u8ComRdEbc1Sa33TractionCtrlOverrideSwitch SWTST_u8ComRdEbc1Sa33TrailerABSStatus SWTST_u8ComRdEbc1Sa33TrctrMntdTrailerABSWarningSignal SWTST_u8ComRdEbc1Sa49ABSEBSAmberWarningSignal SWTST_u8ComRdEbc1Sa49ABSFullyOperational SWTST_u8ComRdEbc1Sa49ABSOffroadSwitch SWTST_u8ComRdEbc1Sa49AccelInterlockSwitch SWTST_u8ComRdEbc1Sa49AntiLockBrakingActive SWTST_u8ComRdEbc1Sa49ASRBrakeCtrlActive SWTST_u8ComRdEbc1Sa49ASREngCtrlActive SWTST_u8ComRdEbc1Sa49ASRHillHolderSwitch SWTST_u8ComRdEbc1Sa49ASROffroadSwitch SWTST_u8ComRdEbc1Sa49ATCASRInformationSignal SWTST_u8ComRdEbc1Sa49EBSBrakeSwitch SWTST_u8ComRdEbc1Sa49EBSRedWarningSignal SWTST_u8ComRdEbc1Sa49EngAuxShutdownSwitch SWTST_u8ComRdEbc1Sa49EngDerateSwitch SWTST_u8ComRdEbc1Sa49HaltBrakeSwitch SWTST_u8ComRdEbc1Sa49RemoteAccelEnableSwitch SWTST_u8ComRdEbc1Sa49SrcAddrssOfCntrllngDvcFrBrkeCtrl SWTST_u8ComRdEbc1Sa49TractionCtrlOverrideSwitch SWTST_u8ComRdEbc1Sa49TrailerABSStatus SWTST_u8ComRdEbc1Sa49TrctrMntdTrailerABSWarningSignal SWTST_u8ComRdEc1Sa00SupportTSC1CtrlPurposeGroup1 SWTST_u8ComRdEc1Sa00SupportTSC1CtrlPurposeGroup2 SWTST_u8ComRdEc1Sa00SupportTSC1CtrlPurposeGroup3 SWTST_u8ComRdEc1Sa00SupportTSC1CtrlPurposeGroup4 SWTST_u8ComRdEc1Sa00SupportVariableRateTSC1Message SWTST_u8ComRdEec1Sa00EngStarterMode SWTST_u8ComRdEec1Sa00EngTorqueMode SWTST_u8ComRdEec1Sa00SrcAddrssOfCntrllngDvcForEngCtrl SWTST_u8ComRdEec2Sa00AccelPedal1LowIdleSwitch SWTST_u8ComRdEec2Sa00AccelPedal2LowIdleSwitch SWTST_u8ComRdEec2Sa00AccelPedalKickdownSwitch SWTST_u8ComRdEec2Sa00DPFThermalManagementActive SWTST_u8ComRdEec2Sa00MmntaryEngMaxPowerEnableFeedback SWTST_u8ComRdEec2Sa00RoadSpeedLimitStatus SWTST_u8ComRdEec2Sa00SCRThermalManagementActive SWTST_u8ComRdEec2Sa00VhcleAccelerationRateLimitStatus SWTST_u8ComRdEec2Sa17AccelPedal1LowIdleSwitch SWTST_u8ComRdEec2Sa17AccelPedal2LowIdleSwitch SWTST_u8ComRdEec2Sa17AccelPedalKickdownSwitch SWTST_u8ComRdEec2Sa17DPFThermalManagementActive SWTST_u8ComRdEec2Sa17MmntaryEngMaxPowerEnableFeedback SWTST_u8ComRdEec2Sa17RoadSpeedLimitStatus SWTST_u8ComRdEec2Sa17SCRThermalManagementActive SWTST_u8ComRdEec2Sa17VhcleAccelerationRateLimitStatus SWTST_u8ComRdEec2Sa33AccelPedal1LowIdleSwitch SWTST_u8ComRdEec2Sa33AccelPedal2LowIdleSwitch SWTST_u8ComRdEec2Sa33AccelPedalKickdownSwitch SWTST_u8ComRdEec2Sa33DPFThermalManagementActive SWTST_u8ComRdEec2Sa33MmntaryEngMaxPowerEnableFeedback SWTST_u8ComRdEec2Sa33RoadSpeedLimitStatus SWTST_u8ComRdEec2Sa33SCRThermalManagementActive SWTST_u8ComRdEec2Sa33VhcleAccelerationRateLimitStatus SWTST_u8ComRdEec2Sa49AccelPedal1LowIdleSwitch SWTST_u8ComRdEec2Sa49AccelPedal2LowIdleSwitch SWTST_u8ComRdEec2Sa49AccelPedalKickdownSwitch SWTST_u8ComRdEec2Sa49DPFThermalManagementActive SWTST_u8ComRdEec2Sa49MmntaryEngMaxPowerEnableFeedback SWTST_u8ComRdEec2Sa49RoadSpeedLimitStatus SWTST_u8ComRdEec2Sa49SCRThermalManagementActive SWTST_u8ComRdEec2Sa49VhcleAccelerationRateLimitStatus SWTST_u8ComRdEec3Sa00AFT1ExhDewPoint SWTST_u8ComRdEec3Sa00AFT1InDewPoint SWTST_u8ComRdEec3Sa00AFT2ExhDewPoint SWTST_u8ComRdEec3Sa00AFT2InDewPoint SWTST_u8ComRdErc1Sa00EngCoolantLoadIncrease SWTST_u8ComRdErc1Sa00RetarderEnableBrakeAssistSwitch SWTST_u8ComRdErc1Sa00RetarderEnableShiftAssistSwitch SWTST_u8ComRdErc1Sa00RetarderRequestingBrakeLight SWTST_u8ComRdErc1Sa00RetarderRoadSpeedExceededStatus SWTST_u8ComRdErc1Sa00RetarderRoadSpeedLimitSwitch SWTST_u8ComRdErc1Sa00RetarderTorqueMode SWTST_u8ComRdErc1Sa00SrcAddrssOfCntrllngDvcFrRtrdrCtr SWTST_u8ComRdErc1Sa15EngCoolantLoadIncrease SWTST_u8ComRdErc1Sa15RetarderEnableBrakeAssistSwitch SWTST_u8ComRdErc1Sa15RetarderEnableShiftAssistSwitch SWTST_u8ComRdErc1Sa15RetarderRequestingBrakeLight SWTST_u8ComRdErc1Sa15RetarderRoadSpeedExceededStatus SWTST_u8ComRdErc1Sa15RetarderRoadSpeedLimitSwitch SWTST_u8ComRdErc1Sa15RetarderTorqueMode SWTST_u8ComRdErc1Sa15SrcAddrssOfCntrllngDvcFrRtrdrCtr SWTST_u8ComRdErc1Sa23EngCoolantLoadIncrease SWTST_u8ComRdErc1Sa23RetarderEnableBrakeAssistSwitch SWTST_u8ComRdErc1Sa23RetarderEnableShiftAssistSwitch SWTST_u8ComRdErc1Sa23RetarderRequestingBrakeLight SWTST_u8ComRdErc1Sa23RetarderRoadSpeedExceededStatus SWTST_u8ComRdErc1Sa23RetarderRoadSpeedLimitSwitch SWTST_u8ComRdErc1Sa23RetarderTorqueMode SWTST_u8ComRdErc1Sa23SrcAddrssOfCntrllngDvcFrRtrdrCtr SWTST_u8ComRdErc1Sa33EngCoolantLoadIncrease SWTST_u8ComRdErc1Sa33RetarderEnableBrakeAssistSwitch SWTST_u8ComRdErc1Sa33RetarderEnableShiftAssistSwitch SWTST_u8ComRdErc1Sa33RetarderRequestingBrakeLight SWTST_u8ComRdErc1Sa33RetarderRoadSpeedExceededStatus SWTST_u8ComRdErc1Sa33RetarderRoadSpeedLimitSwitch SWTST_u8ComRdErc1Sa33RetarderTorqueMode SWTST_u8ComRdErc1Sa33SrcAddrssOfCntrllngDvcFrRtrdrCtr SWTST_u8ComRdErc1Sa41EngCoolantLoadIncrease SWTST_u8ComRdErc1Sa41RetarderEnableBrakeAssistSwitch SWTST_u8ComRdErc1Sa41RetarderEnableShiftAssistSwitch SWTST_u8ComRdErc1Sa41RetarderRequestingBrakeLight SWTST_u8ComRdErc1Sa41RetarderRoadSpeedExceededStatus SWTST_u8ComRdErc1Sa41RetarderRoadSpeedLimitSwitch SWTST_u8ComRdErc1Sa41RetarderTorqueMode SWTST_u8ComRdErc1Sa41SrcAddrssOfCntrllngDvcFrRtrdrCtr SWTST_u8ComRdErc1Sa49EngCoolantLoadIncrease SWTST_u8ComRdErc1Sa49RetarderEnableBrakeAssistSwitch SWTST_u8ComRdErc1Sa49RetarderEnableShiftAssistSwitch SWTST_u8ComRdErc1Sa49RetarderRequestingBrakeLight SWTST_u8ComRdErc1Sa49RetarderRoadSpeedExceededStatus SWTST_u8ComRdErc1Sa49RetarderRoadSpeedLimitSwitch SWTST_u8ComRdErc1Sa49RetarderTorqueMode SWTST_u8ComRdErc1Sa49SrcAddrssOfCntrllngDvcFrRtrdrCtr SWTST_u8ComRdPtodeSa23AtLeastOnePTOEngaged SWTST_u8ComRdPtodeSa23EnableSwitchPTOEngFlywheel SWTST_u8ComRdPtodeSa23EnableSwitchTransInputShaftPTO1 SWTST_u8ComRdPtodeSa23EnableSwitchTransInputShaftPTO2 SWTST_u8ComRdPtodeSa23EnableSwitchTransOutputShaftPTO SWTST_u8ComRdPtodeSa23EnbleSwitchPTOEngAccessoryDrive1 SWTST_u8ComRdPtodeSa23EnbleSwitchPTOEngAccessoryDrive2 SWTST_u8ComRdPtodeSa23EnblSwtchTrnsfrCseOutputShaftPTO SWTST_u8ComRdPtodeSa23EngagementConsentPTOEngFlywheel SWTST_u8ComRdPtodeSa23EngagementStatusPTOEngFlywheel SWTST_u8ComRdPtodeSa23EnggmntCnsentTransInputShaftPTO1 SWTST_u8ComRdPtodeSa23EnggmntCnsentTransInputShaftPTO2 SWTST_u8ComRdPtodeSa23EnggmntCnsentTransOutputShaftPTO SWTST_u8ComRdPtodeSa23EnggmntCnsntPTOEngAccssoryDrive1 SWTST_u8ComRdPtodeSa23EnggmntCnsntPTOEngAccssoryDrive2 SWTST_u8ComRdPtodeSa23EnggmntCnsntTrnsfrCsOtptShaftPTO SWTST_u8ComRdPtodeSa23EnggmntStatusTransInputShaftPTO1 SWTST_u8ComRdPtodeSa23EnggmntStatusTransInputShaftPTO2 SWTST_u8ComRdPtodeSa23EnggmntStatusTransOutputShaftPTO SWTST_u8ComRdPtodeSa23EnggmntSttsPTOEngAccessoryDrive1 SWTST_u8ComRdPtodeSa23EnggmntSttsPTOEngAccessoryDrive2 SWTST_u8ComRdPtodeSa23EnggmntSttsTrnsfrCsOtputShaftPTO SWTST_u8ComRdPtodeSa33AtLeastOnePTOEngaged SWTST_u8ComRdPtodeSa33EnableSwitchPTOEngFlywheel SWTST_u8ComRdPtodeSa33EnableSwitchTransInputShaftPTO1 SWTST_u8ComRdPtodeSa33EnableSwitchTransInputShaftPTO2 SWTST_u8ComRdPtodeSa33EnableSwitchTransOutputShaftPTO SWTST_u8ComRdPtodeSa33EnbleSwitchPTOEngAccessoryDrive1 SWTST_u8ComRdPtodeSa33EnbleSwitchPTOEngAccessoryDrive2 SWTST_u8ComRdPtodeSa33EnblSwtchTrnsfrCseOutputShaftPTO SWTST_u8ComRdPtodeSa33EngagementConsentPTOEngFlywheel SWTST_u8ComRdPtodeSa33EngagementStatusPTOEngFlywheel SWTST_u8ComRdPtodeSa33EnggmntCnsentTransInputShaftPTO1 SWTST_u8ComRdPtodeSa33EnggmntCnsentTransInputShaftPTO2 SWTST_u8ComRdPtodeSa33EnggmntCnsentTransOutputShaftPTO SWTST_u8ComRdPtodeSa33EnggmntCnsntPTOEngAccssoryDrive1 SWTST_u8ComRdPtodeSa33EnggmntCnsntPTOEngAccssoryDrive2 SWTST_u8ComRdPtodeSa33EnggmntCnsntTrnsfrCsOtptShaftPTO SWTST_u8ComRdPtodeSa33EnggmntStatusTransInputShaftPTO1 SWTST_u8ComRdPtodeSa33EnggmntStatusTransInputShaftPTO2 SWTST_u8ComRdPtodeSa33EnggmntStatusTransOutputShaftPTO SWTST_u8ComRdPtodeSa33EnggmntSttsPTOEngAccessoryDrive1 SWTST_u8ComRdPtodeSa33EnggmntSttsPTOEngAccessoryDrive2 SWTST_u8ComRdPtodeSa33EnggmntSttsTrnsfrCsOtputShaftPTO SWTST_u8ComRdPtodeSa49AtLeastOnePTOEngaged SWTST_u8ComRdPtodeSa49EnableSwitchPTOEngFlywheel SWTST_u8ComRdPtodeSa49EnableSwitchTransInputShaftPTO1 SWTST_u8ComRdPtodeSa49EnableSwitchTransInputShaftPTO2 SWTST_u8ComRdPtodeSa49EnableSwitchTransOutputShaftPTO SWTST_u8ComRdPtodeSa49EnbleSwitchPTOEngAccessoryDrive1 SWTST_u8ComRdPtodeSa49EnbleSwitchPTOEngAccessoryDrive2 SWTST_u8ComRdPtodeSa49EnblSwtchTrnsfrCseOutputShaftPTO SWTST_u8ComRdPtodeSa49EngagementConsentPTOEngFlywheel SWTST_u8ComRdPtodeSa49EngagementStatusPTOEngFlywheel SWTST_u8ComRdPtodeSa49EnggmntCnsentTransInputShaftPTO1 SWTST_u8ComRdPtodeSa49EnggmntCnsentTransInputShaftPTO2 SWTST_u8ComRdPtodeSa49EnggmntCnsentTransOutputShaftPTO /end OUT_MEASUREMENT
/end FUNCTION
/end MODULE
/end PROJECT
