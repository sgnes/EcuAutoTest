ASAP2_VERSION 1 70
/begin PROJECT TEST_PROJECT "TEST_PROJECT"
/begin HEADER "TEST_PROJECT" PROJECT_NO D0 VERSION "3095.02" /end HEADER
/begin MODULE TEST_PROJECT "TestSupplier"
/begin MOD_COMMON "" DEPOSIT ABSOLUTE BYTE_ORDER MSB_LAST ALIGNMENT_BYTE 1 ALIGNMENT_WORD 2 ALIGNMENT_LONG 4 ALIGNMENT_INT64 1 ALIGNMENT_FLOAT32_IEEE 4 ALIGNMENT_FLOAT64_IEEE 8 /end MOD_COMMON
/begin MEASUREMENT SWTST_BoolEnErrValDiagc "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A74 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_DEM_u16EventIdCCP "SWTST_DEM_u16EventIdCCP" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E6E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_DEM_u8DisDebounce "SWTST_DEM_u8DisDebounce" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001251A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_DEM_u8EventFlagCCP "SWTST_DEM_u8EventFlagCCP" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012519 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[269] "SWTST_au8FimDemEveStsReal[269]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012693 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[26] "SWTST_au8FimDemEveStsReal[26]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125A0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[270] "SWTST_au8FimDemEveStsReal[270]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012694 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[271] "SWTST_au8FimDemEveStsReal[271]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012695 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[272] "SWTST_au8FimDemEveStsReal[272]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012696 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[273] "SWTST_au8FimDemEveStsReal[273]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012697 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[274] "SWTST_au8FimDemEveStsReal[274]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012698 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[275] "SWTST_au8FimDemEveStsReal[275]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012699 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[276] "SWTST_au8FimDemEveStsReal[276]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001269A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[277] "SWTST_au8FimDemEveStsReal[277]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001269B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[278] "SWTST_au8FimDemEveStsReal[278]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001269C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[279] "SWTST_au8FimDemEveStsReal[279]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001269D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[27] "SWTST_au8FimDemEveStsReal[27]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125A1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[280] "SWTST_au8FimDemEveStsReal[280]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001269E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[281] "SWTST_au8FimDemEveStsReal[281]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001269F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[282] "SWTST_au8FimDemEveStsReal[282]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126A0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[283] "SWTST_au8FimDemEveStsReal[283]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126A1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[284] "SWTST_au8FimDemEveStsReal[284]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126A2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[285] "SWTST_au8FimDemEveStsReal[285]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126A3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[286] "SWTST_au8FimDemEveStsReal[286]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126A4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[287] "SWTST_au8FimDemEveStsReal[287]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126A5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[288] "SWTST_au8FimDemEveStsReal[288]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126A6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[289] "SWTST_au8FimDemEveStsReal[289]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126A7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[28] "SWTST_au8FimDemEveStsReal[28]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125A2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[290] "SWTST_au8FimDemEveStsReal[290]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126A8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[291] "SWTST_au8FimDemEveStsReal[291]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126A9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[292] "SWTST_au8FimDemEveStsReal[292]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126AA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[293] "SWTST_au8FimDemEveStsReal[293]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126AB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[294] "SWTST_au8FimDemEveStsReal[294]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[295] "SWTST_au8FimDemEveStsReal[295]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126AD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[296] "SWTST_au8FimDemEveStsReal[296]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126AE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[297] "SWTST_au8FimDemEveStsReal[297]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126AF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[298] "SWTST_au8FimDemEveStsReal[298]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126B0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[299] "SWTST_au8FimDemEveStsReal[299]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126B1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[29] "SWTST_au8FimDemEveStsReal[29]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125A3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[2] "SWTST_au8FimDemEveStsReal[2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012588 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[300] "SWTST_au8FimDemEveStsReal[300]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126B2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[301] "SWTST_au8FimDemEveStsReal[301]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126B3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[302] "SWTST_au8FimDemEveStsReal[302]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126B4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[303] "SWTST_au8FimDemEveStsReal[303]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126B5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[304] "SWTST_au8FimDemEveStsReal[304]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126B6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[305] "SWTST_au8FimDemEveStsReal[305]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126B7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[306] "SWTST_au8FimDemEveStsReal[306]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126B8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[307] "SWTST_au8FimDemEveStsReal[307]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126B9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[308] "SWTST_au8FimDemEveStsReal[308]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126BA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[309] "SWTST_au8FimDemEveStsReal[309]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126BB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[30] "SWTST_au8FimDemEveStsReal[30]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125A4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[310] "SWTST_au8FimDemEveStsReal[310]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126BC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[311] "SWTST_au8FimDemEveStsReal[311]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126BD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[312] "SWTST_au8FimDemEveStsReal[312]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126BE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[313] "SWTST_au8FimDemEveStsReal[313]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126BF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[314] "SWTST_au8FimDemEveStsReal[314]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126C0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[315] "SWTST_au8FimDemEveStsReal[315]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126C1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[316] "SWTST_au8FimDemEveStsReal[316]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126C2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[317] "SWTST_au8FimDemEveStsReal[317]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126C3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[318] "SWTST_au8FimDemEveStsReal[318]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126C4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[319] "SWTST_au8FimDemEveStsReal[319]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126C5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[31] "SWTST_au8FimDemEveStsReal[31]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125A5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[320] "SWTST_au8FimDemEveStsReal[320]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126C6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[321] "SWTST_au8FimDemEveStsReal[321]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126C7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[322] "SWTST_au8FimDemEveStsReal[322]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126C8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[323] "SWTST_au8FimDemEveStsReal[323]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126C9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[324] "SWTST_au8FimDemEveStsReal[324]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126CA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[325] "SWTST_au8FimDemEveStsReal[325]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126CB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[326] "SWTST_au8FimDemEveStsReal[326]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126CC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[327] "SWTST_au8FimDemEveStsReal[327]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126CD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[328] "SWTST_au8FimDemEveStsReal[328]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126CE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[329] "SWTST_au8FimDemEveStsReal[329]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126CF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[32] "SWTST_au8FimDemEveStsReal[32]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125A6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[330] "SWTST_au8FimDemEveStsReal[330]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126D0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[331] "SWTST_au8FimDemEveStsReal[331]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126D1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[332] "SWTST_au8FimDemEveStsReal[332]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126D2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[333] "SWTST_au8FimDemEveStsReal[333]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126D3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[334] "SWTST_au8FimDemEveStsReal[334]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126D4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[335] "SWTST_au8FimDemEveStsReal[335]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126D5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[336] "SWTST_au8FimDemEveStsReal[336]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126D6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[337] "SWTST_au8FimDemEveStsReal[337]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126D7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[338] "SWTST_au8FimDemEveStsReal[338]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126D8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[339] "SWTST_au8FimDemEveStsReal[339]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126D9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[33] "SWTST_au8FimDemEveStsReal[33]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125A7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[340] "SWTST_au8FimDemEveStsReal[340]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126DA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[341] "SWTST_au8FimDemEveStsReal[341]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126DB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[342] "SWTST_au8FimDemEveStsReal[342]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126DC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[343] "SWTST_au8FimDemEveStsReal[343]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126DD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[344] "SWTST_au8FimDemEveStsReal[344]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126DE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[345] "SWTST_au8FimDemEveStsReal[345]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126DF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[346] "SWTST_au8FimDemEveStsReal[346]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126E0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[347] "SWTST_au8FimDemEveStsReal[347]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126E1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[348] "SWTST_au8FimDemEveStsReal[348]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126E2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[349] "SWTST_au8FimDemEveStsReal[349]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126E3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[34] "SWTST_au8FimDemEveStsReal[34]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125A8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[350] "SWTST_au8FimDemEveStsReal[350]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126E4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[351] "SWTST_au8FimDemEveStsReal[351]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126E5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[352] "SWTST_au8FimDemEveStsReal[352]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126E6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[353] "SWTST_au8FimDemEveStsReal[353]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126E7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[354] "SWTST_au8FimDemEveStsReal[354]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600126E8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[35] "SWTST_au8FimDemEveStsReal[35]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125A9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[36] "SWTST_au8FimDemEveStsReal[36]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125AA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[37] "SWTST_au8FimDemEveStsReal[37]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125AB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[38] "SWTST_au8FimDemEveStsReal[38]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[39] "SWTST_au8FimDemEveStsReal[39]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125AD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[3] "SWTST_au8FimDemEveStsReal[3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012589 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[40] "SWTST_au8FimDemEveStsReal[40]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125AE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[41] "SWTST_au8FimDemEveStsReal[41]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125AF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[42] "SWTST_au8FimDemEveStsReal[42]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125B0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[43] "SWTST_au8FimDemEveStsReal[43]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125B1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[44] "SWTST_au8FimDemEveStsReal[44]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125B2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[45] "SWTST_au8FimDemEveStsReal[45]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125B3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[46] "SWTST_au8FimDemEveStsReal[46]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125B4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[47] "SWTST_au8FimDemEveStsReal[47]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125B5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[48] "SWTST_au8FimDemEveStsReal[48]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125B6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[49] "SWTST_au8FimDemEveStsReal[49]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125B7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[4] "SWTST_au8FimDemEveStsReal[4]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001258A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[50] "SWTST_au8FimDemEveStsReal[50]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125B8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[51] "SWTST_au8FimDemEveStsReal[51]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125B9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[52] "SWTST_au8FimDemEveStsReal[52]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125BA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[53] "SWTST_au8FimDemEveStsReal[53]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125BB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[54] "SWTST_au8FimDemEveStsReal[54]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125BC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[55] "SWTST_au8FimDemEveStsReal[55]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125BD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[56] "SWTST_au8FimDemEveStsReal[56]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125BE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[57] "SWTST_au8FimDemEveStsReal[57]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125BF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[58] "SWTST_au8FimDemEveStsReal[58]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125C0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[59] "SWTST_au8FimDemEveStsReal[59]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125C1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[5] "SWTST_au8FimDemEveStsReal[5]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001258B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[60] "SWTST_au8FimDemEveStsReal[60]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125C2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[61] "SWTST_au8FimDemEveStsReal[61]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125C3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[62] "SWTST_au8FimDemEveStsReal[62]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125C4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[63] "SWTST_au8FimDemEveStsReal[63]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125C5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[64] "SWTST_au8FimDemEveStsReal[64]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125C6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[65] "SWTST_au8FimDemEveStsReal[65]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125C7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[66] "SWTST_au8FimDemEveStsReal[66]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125C8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[67] "SWTST_au8FimDemEveStsReal[67]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125C9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[68] "SWTST_au8FimDemEveStsReal[68]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125CA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[69] "SWTST_au8FimDemEveStsReal[69]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125CB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[6] "SWTST_au8FimDemEveStsReal[6]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001258C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[70] "SWTST_au8FimDemEveStsReal[70]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125CC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[71] "SWTST_au8FimDemEveStsReal[71]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125CD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[72] "SWTST_au8FimDemEveStsReal[72]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125CE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[73] "SWTST_au8FimDemEveStsReal[73]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125CF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[74] "SWTST_au8FimDemEveStsReal[74]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125D0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[75] "SWTST_au8FimDemEveStsReal[75]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125D1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[76] "SWTST_au8FimDemEveStsReal[76]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125D2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[77] "SWTST_au8FimDemEveStsReal[77]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125D3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[78] "SWTST_au8FimDemEveStsReal[78]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125D4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[79] "SWTST_au8FimDemEveStsReal[79]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125D5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[7] "SWTST_au8FimDemEveStsReal[7]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001258D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[80] "SWTST_au8FimDemEveStsReal[80]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125D6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[81] "SWTST_au8FimDemEveStsReal[81]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125D7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[82] "SWTST_au8FimDemEveStsReal[82]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125D8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[83] "SWTST_au8FimDemEveStsReal[83]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125D9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[84] "SWTST_au8FimDemEveStsReal[84]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125DA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[85] "SWTST_au8FimDemEveStsReal[85]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125DB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[86] "SWTST_au8FimDemEveStsReal[86]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125DC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[87] "SWTST_au8FimDemEveStsReal[87]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125DD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[88] "SWTST_au8FimDemEveStsReal[88]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125DE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[89] "SWTST_au8FimDemEveStsReal[89]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125DF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[8] "SWTST_au8FimDemEveStsReal[8]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001258E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[90] "SWTST_au8FimDemEveStsReal[90]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125E0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[91] "SWTST_au8FimDemEveStsReal[91]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125E1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[92] "SWTST_au8FimDemEveStsReal[92]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125E2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[93] "SWTST_au8FimDemEveStsReal[93]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125E3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[94] "SWTST_au8FimDemEveStsReal[94]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125E4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[95] "SWTST_au8FimDemEveStsReal[95]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125E5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[96] "SWTST_au8FimDemEveStsReal[96]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125E6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[97] "SWTST_au8FimDemEveStsReal[97]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125E7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[98] "SWTST_au8FimDemEveStsReal[98]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125E8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[99] "SWTST_au8FimDemEveStsReal[99]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600125E9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimDemEveStsReal[9] "SWTST_au8FimDemEveStsReal[9]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001258F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimFidPerm "Last test done" UBYTE I_5 1 2 0 255 MATRIX_DIM 20 1 1 ECU_ADDRESS 0x60012572 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimFidPerm[0] "SWTST_au8FimFidPerm[0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012572 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimFidPerm[10] "SWTST_au8FimFidPerm[10]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001257C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimFidPerm[11] "SWTST_au8FimFidPerm[11]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001257D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimFidPerm[12] "SWTST_au8FimFidPerm[12]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001257E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimFidPerm[13] "SWTST_au8FimFidPerm[13]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001257F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimFidPerm[14] "SWTST_au8FimFidPerm[14]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012580 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimFidPerm[15] "SWTST_au8FimFidPerm[15]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012581 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimFidPerm[16] "SWTST_au8FimFidPerm[16]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012582 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimFidPerm[17] "SWTST_au8FimFidPerm[17]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012583 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimFidPerm[18] "SWTST_au8FimFidPerm[18]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012584 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimFidPerm[19] "SWTST_au8FimFidPerm[19]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012585 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimFidPerm[1] "SWTST_au8FimFidPerm[1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012573 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimFidPerm[2] "SWTST_au8FimFidPerm[2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012574 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimFidPerm[3] "SWTST_au8FimFidPerm[3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012575 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimFidPerm[4] "SWTST_au8FimFidPerm[4]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012576 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimFidPerm[5] "SWTST_au8FimFidPerm[5]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012577 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimFidPerm[6] "SWTST_au8FimFidPerm[6]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012578 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimFidPerm[7] "SWTST_au8FimFidPerm[7]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012579 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimFidPerm[8] "SWTST_au8FimFidPerm[8]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001257A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8FimFidPerm[9] "SWTST_au8FimFidPerm[9]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001257B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8Tle62X0RdDiag "SWTST_au8Tle62X0RdDiag" UBYTE Id_0x00 1 2 0 255 MATRIX_DIM 12 1 1 ECU_ADDRESS 0x60012566 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8Tle62X0RdDiag[0] "SWTST_au8Tle62X0RdDiag[0]" UBYTE Id_0x00 1 2 0 255 ECU_ADDRESS 0x60012566 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8Tle62X0RdDiag[10] "SWTST_au8Tle62X0RdDiag[10]" UBYTE Id_0x00 1 2 0 255 ECU_ADDRESS 0x60012570 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8Tle62X0RdDiag[11] "SWTST_au8Tle62X0RdDiag[11]" UBYTE Id_0x00 1 2 0 255 ECU_ADDRESS 0x60012571 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8Tle62X0RdDiag[1] "SWTST_au8Tle62X0RdDiag[1]" UBYTE Id_0x00 1 2 0 255 ECU_ADDRESS 0x60012567 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8Tle62X0RdDiag[2] "SWTST_au8Tle62X0RdDiag[2]" UBYTE Id_0x00 1 2 0 255 ECU_ADDRESS 0x60012568 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8Tle62X0RdDiag[3] "SWTST_au8Tle62X0RdDiag[3]" UBYTE Id_0x00 1 2 0 255 ECU_ADDRESS 0x60012569 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8Tle62X0RdDiag[4] "SWTST_au8Tle62X0RdDiag[4]" UBYTE Id_0x00 1 2 0 255 ECU_ADDRESS 0x6001256A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8Tle62X0RdDiag[5] "SWTST_au8Tle62X0RdDiag[5]" UBYTE Id_0x00 1 2 0 255 ECU_ADDRESS 0x6001256B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8Tle62X0RdDiag[6] "SWTST_au8Tle62X0RdDiag[6]" UBYTE Id_0x00 1 2 0 255 ECU_ADDRESS 0x6001256C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8Tle62X0RdDiag[7] "SWTST_au8Tle62X0RdDiag[7]" UBYTE Id_0x00 1 2 0 255 ECU_ADDRESS 0x6001256D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8Tle62X0RdDiag[8] "SWTST_au8Tle62X0RdDiag[8]" UBYTE Id_0x00 1 2 0 255 ECU_ADDRESS 0x6001256E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_au8Tle62X0RdDiag[9] "SWTST_au8Tle62X0RdDiag[9]" UBYTE Id_0x00 1 2 0 255 ECU_ADDRESS 0x6001256F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242OpenFltTst "solenoid open fault status" UBYTE I_5 1 2 0 255 MATRIX_DIM 15 1 1 ECU_ADDRESS 0x60012557 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242OpenFltTst[0] "SWTST_avu8Tle8242OpenFltTst[0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012557 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242OpenFltTst[10] "SWTST_avu8Tle8242OpenFltTst[10]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012561 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242OpenFltTst[11] "SWTST_avu8Tle8242OpenFltTst[11]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012562 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242OpenFltTst[12] "SWTST_avu8Tle8242OpenFltTst[12]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012563 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242OpenFltTst[13] "SWTST_avu8Tle8242OpenFltTst[13]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012564 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242OpenFltTst[14] "SWTST_avu8Tle8242OpenFltTst[14]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012565 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242OpenFltTst[1] "SWTST_avu8Tle8242OpenFltTst[1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012558 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242OpenFltTst[2] "SWTST_avu8Tle8242OpenFltTst[2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012559 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242OpenFltTst[3] "SWTST_avu8Tle8242OpenFltTst[3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001255A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242OpenFltTst[4] "SWTST_avu8Tle8242OpenFltTst[4]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001255B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242OpenFltTst[5] "SWTST_avu8Tle8242OpenFltTst[5]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001255C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242OpenFltTst[6] "SWTST_avu8Tle8242OpenFltTst[6]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001255D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242OpenFltTst[7] "SWTST_avu8Tle8242OpenFltTst[7]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001255E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242OpenFltTst[8] "SWTST_avu8Tle8242OpenFltTst[8]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001255F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242OpenFltTst[9] "SWTST_avu8Tle8242OpenFltTst[9]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012560 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242OverLoadFltTst "solenoid OverLoad fault status" UBYTE I_5 1 2 0 255 MATRIX_DIM 15 1 1 ECU_ADDRESS 0x60012548 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242OverLoadFltTst[0] "SWTST_avu8Tle8242OverLoadFltTst[0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012548 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242OverLoadFltTst[10] "SWTST_avu8Tle8242OverLoadFltTst[10]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012552 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242OverLoadFltTst[11] "SWTST_avu8Tle8242OverLoadFltTst[11]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012553 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242OverLoadFltTst[12] "SWTST_avu8Tle8242OverLoadFltTst[12]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012554 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242OverLoadFltTst[13] "SWTST_avu8Tle8242OverLoadFltTst[13]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012555 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242OverLoadFltTst[14] "SWTST_avu8Tle8242OverLoadFltTst[14]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012556 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242OverLoadFltTst[1] "SWTST_avu8Tle8242OverLoadFltTst[1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012549 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242OverLoadFltTst[2] "SWTST_avu8Tle8242OverLoadFltTst[2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001254A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242OverLoadFltTst[3] "SWTST_avu8Tle8242OverLoadFltTst[3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001254B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242OverLoadFltTst[4] "SWTST_avu8Tle8242OverLoadFltTst[4]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001254C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242OverLoadFltTst[5] "SWTST_avu8Tle8242OverLoadFltTst[5]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001254D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242OverLoadFltTst[6] "SWTST_avu8Tle8242OverLoadFltTst[6]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001254E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242OverLoadFltTst[7] "SWTST_avu8Tle8242OverLoadFltTst[7]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001254F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242OverLoadFltTst[8] "SWTST_avu8Tle8242OverLoadFltTst[8]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012550 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242OverLoadFltTst[9] "SWTST_avu8Tle8242OverLoadFltTst[9]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012551 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242ScFltTst "solenoid short to ground status" UBYTE I_5 1 2 0 255 MATRIX_DIM 15 1 1 ECU_ADDRESS 0x60012539 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242ScFltTst[0] "SWTST_avu8Tle8242ScFltTst[0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012539 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242ScFltTst[10] "SWTST_avu8Tle8242ScFltTst[10]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012543 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242ScFltTst[11] "SWTST_avu8Tle8242ScFltTst[11]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012544 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242ScFltTst[12] "SWTST_avu8Tle8242ScFltTst[12]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012545 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242ScFltTst[13] "SWTST_avu8Tle8242ScFltTst[13]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012546 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242ScFltTst[14] "SWTST_avu8Tle8242ScFltTst[14]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012547 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242ScFltTst[1] "SWTST_avu8Tle8242ScFltTst[1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001253A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242ScFltTst[2] "SWTST_avu8Tle8242ScFltTst[2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001253B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242ScFltTst[3] "SWTST_avu8Tle8242ScFltTst[3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001253C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242ScFltTst[4] "SWTST_avu8Tle8242ScFltTst[4]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001253D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242ScFltTst[5] "SWTST_avu8Tle8242ScFltTst[5]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001253E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242ScFltTst[6] "SWTST_avu8Tle8242ScFltTst[6]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001253F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242ScFltTst[7] "SWTST_avu8Tle8242ScFltTst[7]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012540 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242ScFltTst[8] "SWTST_avu8Tle8242ScFltTst[8]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012541 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242ScFltTst[9] "SWTST_avu8Tle8242ScFltTst[9]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012542 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242ScsFltTst "solenoid short to battery status" UBYTE I_5 1 2 0 255 MATRIX_DIM 15 1 1 ECU_ADDRESS 0x6001252A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242ScsFltTst[0] "SWTST_avu8Tle8242ScsFltTst[0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001252A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242ScsFltTst[10] "SWTST_avu8Tle8242ScsFltTst[10]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012534 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242ScsFltTst[11] "SWTST_avu8Tle8242ScsFltTst[11]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012535 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242ScsFltTst[12] "SWTST_avu8Tle8242ScsFltTst[12]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012536 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242ScsFltTst[13] "SWTST_avu8Tle8242ScsFltTst[13]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012537 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242ScsFltTst[14] "SWTST_avu8Tle8242ScsFltTst[14]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012538 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242ScsFltTst[1] "SWTST_avu8Tle8242ScsFltTst[1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001252B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242ScsFltTst[2] "SWTST_avu8Tle8242ScsFltTst[2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001252C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242ScsFltTst[3] "SWTST_avu8Tle8242ScsFltTst[3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001252D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242ScsFltTst[4] "SWTST_avu8Tle8242ScsFltTst[4]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001252E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242ScsFltTst[5] "SWTST_avu8Tle8242ScsFltTst[5]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001252F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242ScsFltTst[6] "SWTST_avu8Tle8242ScsFltTst[6]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012530 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242ScsFltTst[7] "SWTST_avu8Tle8242ScsFltTst[7]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012531 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242ScsFltTst[8] "SWTST_avu8Tle8242ScsFltTst[8]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012532 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242ScsFltTst[9] "SWTST_avu8Tle8242ScsFltTst[9]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012533 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242UnderLoadFltTst "solenoid UnderLoad fault status" UBYTE I_5 1 2 0 255 MATRIX_DIM 15 1 1 ECU_ADDRESS 0x6001251B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242UnderLoadFltTst[0] "SWTST_avu8Tle8242UnderLoadFltTst[0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001251B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242UnderLoadFltTst[10] "SWTST_avu8Tle8242UnderLoadFltTst[10]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012525 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242UnderLoadFltTst[11] "SWTST_avu8Tle8242UnderLoadFltTst[11]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012526 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242UnderLoadFltTst[12] "SWTST_avu8Tle8242UnderLoadFltTst[12]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012527 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242UnderLoadFltTst[13] "SWTST_avu8Tle8242UnderLoadFltTst[13]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012528 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242UnderLoadFltTst[14] "SWTST_avu8Tle8242UnderLoadFltTst[14]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012529 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242UnderLoadFltTst[1] "SWTST_avu8Tle8242UnderLoadFltTst[1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001251C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242UnderLoadFltTst[2] "SWTST_avu8Tle8242UnderLoadFltTst[2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001251D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242UnderLoadFltTst[3] "SWTST_avu8Tle8242UnderLoadFltTst[3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001251E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242UnderLoadFltTst[4] "SWTST_avu8Tle8242UnderLoadFltTst[4]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001251F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242UnderLoadFltTst[5] "SWTST_avu8Tle8242UnderLoadFltTst[5]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012520 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242UnderLoadFltTst[6] "SWTST_avu8Tle8242UnderLoadFltTst[6]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012521 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242UnderLoadFltTst[7] "SWTST_avu8Tle8242UnderLoadFltTst[7]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012522 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242UnderLoadFltTst[8] "SWTST_avu8Tle8242UnderLoadFltTst[8]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012523 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_avu8Tle8242UnderLoadFltTst[9] "SWTST_avu8Tle8242UnderLoadFltTst[9]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012524 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdDiSpareDigitalInput "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014AAE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdDigitalSpare "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014AAF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdHybrid "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014AAD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStb1 "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014AAC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStb1Raw "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014AAB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStb2 "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014AAA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStb2Raw "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014AA9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStb3 "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014AA8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStb3Raw "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014AA7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStb4 "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014AA6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStb4Raw "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014AA5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStb5 "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014AA4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStb5Raw "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014AA3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStb6 "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014AA2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStb6Raw "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014AA1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStb7 "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014AA0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStb7Raw "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A9F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStb8 "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A9E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStb8Raw "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A9D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg1 "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A9C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg10 "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A9B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg10Raw "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A9A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg11 "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A99 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg11Raw "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A98 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg12 "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A97 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg12Raw "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A96 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg13 "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A95 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg13Raw "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A94 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg14 "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A93 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg14Raw "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A92 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg15 "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A91 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg15Raw "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A90 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg16 "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A8F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg16Raw "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A8E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg17 "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A8D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg17Raw "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A8C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg18 "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A8B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg18Raw "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A8A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg19 "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A89 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg19Raw "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A88 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg1Raw "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A87 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg2 "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A86 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg2Raw "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A85 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg3 "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A84 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg3Raw "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A83 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg4 "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A82 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg4Raw "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A81 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg5 "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A80 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg5Raw "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A7F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg6 "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A7E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg6Raw "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A7D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg7 "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A7C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg7Raw "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A7B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg8 "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A7A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg8Raw "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A79 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg9 "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A78 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdInStg9Raw "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A77 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdStartupIgk "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A76 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bDioRdSupplySafeState "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A75 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bSftyClrCurSafeStsFlg "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A73 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bSftyClrPreSafeStsFlg "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A72 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bSftyClrPreSafeStsRetVal "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A71 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bSftyOutOfRngTstFlg "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A70 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bSftySwRstFlg "State of input" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A6F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bSwcSSAuxOnOFfCmd "state" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A6E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bSwcSSDualArPisCmd "state" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A6D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bSwcSSLimpHomeSafCmd "state" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A6C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bSwcSSRetAccCmd "state" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A6B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_bSwcSSSelectCoolCmd "state" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A6A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32AccelXAxis "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600151B8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32AccelYAxis "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600151B4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32AccelZAxis "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600151B0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdCcvs1Sa00CruiseCtrlSetSpeed "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600151AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdCcvs1Sa00WheelBasedVehicleSpeed "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600151A8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdCcvs1Sa17CruiseCtrlSetSpeed "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600151A4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdCcvs1Sa17WheelBasedVehicleSpeed "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600151A0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdCcvs1Sa232CruiseCtrlSetSpeed "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6001519C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdCcvs1Sa232WheelBasedVehicleSpeed "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015198 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdCcvs1Sa23CruiseCtrlSetSpeed "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015194 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdCcvs1Sa23WheelBasedVehicleSpeed "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015190 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdCcvs1Sa33CruiseCtrlSetSpeed "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6001518C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdCcvs1Sa33WheelBasedVehicleSpeed "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015188 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdCcvs1Sa39CruiseCtrlSetSpeed "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015184 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdCcvs1Sa39WheelBasedVehicleSpeed "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015180 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdCcvs1Sa49CruiseCtrlSetSpeed "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6001517C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdCcvs1Sa49WheelBasedVehicleSpeed "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015178 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEbc1Sa00BrakePedalPos "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015174 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEbc1Sa00EngRetarderSelection "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015170 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEbc1Sa11BrakePedalPos "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6001516C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEbc1Sa11EngRetarderSelection "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015168 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEbc1Sa23BrakePedalPos "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015164 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEbc1Sa23EngRetarderSelection "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015160 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEbc1Sa33BrakePedalPos "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6001515C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEbc1Sa33EngRetarderSelection "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015158 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEbc1Sa49BrakePedalPos "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015154 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEbc1Sa49EngRetarderSelection "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015150 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEc1Sa00EngDefaultTorqueLimit "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6001514C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEc1Sa00EngExRngRqstdSpdCtrlRngUpprLimit "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015148 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEc1Sa00EngGain "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015144 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEc1Sa00EngMaxMomentaryOverrideTimeLimit "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015140 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEc1Sa00EngMomentOfInertia "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6001513C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEc1Sa00EngMxMmentaryOverrideSpeedPoint7 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015138 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEc1Sa00EngPercentTorqueAtIdlePoint1 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015134 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEc1Sa00EngPercentTorqueAtPoint2 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015130 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEc1Sa00EngPercentTorqueAtPoint3 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6001512C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEc1Sa00EngPercentTorqueAtPoint4 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015128 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEc1Sa00EngPercentTorqueAtPoint5 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015124 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEc1Sa00EngReferenceTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015120 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEc1Sa00EngRqstdSpeedCtrlRangeLowerLimit "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6001511C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEc1Sa00EngRqstdSpeedCtrlRangeUpperLimit "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015118 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEc1Sa00EngRqstdTrqueCtrlRangeLowerLimit "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015114 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEc1Sa00EngRqstdTrqueCtrlRangeUpperLimit "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015110 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEc1Sa00EngSpeedAtHighIdlePoint6 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6001510C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEc1Sa00EngSpeedAtIdlePoint1 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015108 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEc1Sa00EngSpeedAtPoint2 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015104 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEc1Sa00EngSpeedAtPoint3 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015100 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEc1Sa00EngSpeedAtPoint4 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600150FC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEc1Sa00EngSpeedAtPoint5 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600150F8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEec1Sa00ActlEngPrcntTorqueHighResolution "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600150F4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEec1Sa00ActualEngPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600150F0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEec1Sa00DriversDemandEngPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600150EC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEec1Sa00EngDemandPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600150E8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEec1Sa00EngSpeed "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600150E4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEec2Sa00AccelPedalPos1 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600150E0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEec2Sa00AccelPedalPos2 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600150DC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEec2Sa00ActlMaxAvailableEngPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600150D8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEec2Sa00EngPercentLoadAtCurrentSpeed "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600150D4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEec2Sa00EstPumpingPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600150D0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEec2Sa00RemoteAccelPedalPos "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600150CC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEec2Sa17AccelPedalPos1 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600150C8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEec2Sa17AccelPedalPos2 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600150C4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEec2Sa17ActlMaxAvailableEngPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600150C0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEec2Sa17EngPercentLoadAtCurrentSpeed "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600150BC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEec2Sa17EstPumpingPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600150B8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEec2Sa17RemoteAccelPedalPos "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600150B4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEec2Sa33AccelPedalPos1 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600150B0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEec2Sa33AccelPedalPos2 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600150AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEec2Sa33ActlMaxAvailableEngPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600150A8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEec2Sa33EngPercentLoadAtCurrentSpeed "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600150A4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEec2Sa33EstPumpingPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x600150A0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEec2Sa33RemoteAccelPedalPos "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6001509C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEec2Sa49AccelPedalPos1 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015098 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEec2Sa49AccelPedalPos2 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015094 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEec2Sa49ActlMaxAvailableEngPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015090 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEec2Sa49EngPercentLoadAtCurrentSpeed "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6001508C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEec2Sa49EstPumpingPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015088 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEec2Sa49RemoteAccelPedalPos "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015084 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEec3Sa00AFT1ExhGasMFR "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015080 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEec3Sa00EnginesDesiredOperatingSpeed "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6001507C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEec3Sa00EngnsDsrdOprtngSpdAsymmtryAdjstm "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015078 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEec3Sa00EstEngPrsiticLossesPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015074 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEec3Sa00NominalFrictionPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015070 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdErc1Sa00ActlMxAvlblRetarderPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6001506C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdErc1Sa00ActualRetarderPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015068 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdErc1Sa00DrvrsDemandRetarderPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015064 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdErc1Sa00IntendedRetarderPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015060 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdErc1Sa00RetarderSelectionNonengine "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6001505C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdErc1Sa15ActlMxAvlblRetarderPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015058 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdErc1Sa15ActualRetarderPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015054 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdErc1Sa15DrvrsDemandRetarderPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015050 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdErc1Sa15IntendedRetarderPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6001504C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdErc1Sa15RetarderSelectionNonengine "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015048 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdErc1Sa23ActlMxAvlblRetarderPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015044 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdErc1Sa23ActualRetarderPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015040 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdErc1Sa23DrvrsDemandRetarderPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6001503C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdErc1Sa23IntendedRetarderPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015038 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdErc1Sa23RetarderSelectionNonengine "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015034 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdErc1Sa33ActlMxAvlblRetarderPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015030 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdErc1Sa33ActualRetarderPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6001502C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdErc1Sa33DrvrsDemandRetarderPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015028 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdErc1Sa33IntendedRetarderPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015024 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdErc1Sa33RetarderSelectionNonengine "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015020 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdErc1Sa41ActlMxAvlblRetarderPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6001501C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdErc1Sa41ActualRetarderPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015018 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdErc1Sa41DrvrsDemandRetarderPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015014 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdErc1Sa41IntendedRetarderPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015010 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdErc1Sa41RetarderSelectionNonengine "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x6001500C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdErc1Sa49ActlMxAvlblRetarderPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015008 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdErc1Sa49ActualRetarderPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015004 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdErc1Sa49DrvrsDemandRetarderPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60015000 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdErc1Sa49IntendedRetarderPercentTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014FFC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdErc1Sa49RetarderSelectionNonengine "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014FF8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEt1Sa00EngCoolantTemp "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014FF4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEt1Sa00EngFuelTemp1 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014FF0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEt1Sa00EngIntercoolerTemp "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014FEC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEt1Sa00EngIntercoolerThermostatOpening "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014FE8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEt1Sa00EngOilTemp1 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014FE4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdEt1Sa00EngTurboOilTemp "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014FE0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdLfeSa00EngAverageFuelEconomy "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014FDC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdLfeSa00EngFuelRate "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014FD8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdLfeSa00EngInstantaneousFuelEconomy "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014FD4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdLfeSa00EngThrottleValve1Pos "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014FD0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdLfeSa00EngThrottleValve2Pos "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014FCC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRcSa15MaxRetarderSpeedPoint2 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014FC8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRcSa15PercentTorqueAtIdlePoint1 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014FC4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRcSa15PercentTorqueAtMaxSpeedPoint2 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014FC0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRcSa15PercentTorqueAtPeakTorquePoint5 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014FBC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRcSa15PercentTorqueAtPoint3 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014FB8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRcSa15PercentTorqueAtPoint4 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014FB4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRcSa15ReferenceRetarderTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014FB0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRcSa15RetarderSpeedAtIdlePoint1 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014FAC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRcSa15RetarderSpeedAtPeakTorquePoint5 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014FA8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRcSa15RetarderSpeedAtPoint3 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014FA4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRcSa15RetarderSpeedAtPoint4 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014FA0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRcSa41MaxRetarderSpeedPoint2 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F9C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRcSa41PercentTorqueAtIdlePoint1 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F98 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRcSa41PercentTorqueAtMaxSpeedPoint2 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F94 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRcSa41PercentTorqueAtPeakTorquePoint5 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F90 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRcSa41PercentTorqueAtPoint3 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F8C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRcSa41PercentTorqueAtPoint4 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F88 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRcSa41ReferenceRetarderTorque "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F84 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRcSa41RetarderSpeedAtIdlePoint1 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F80 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRcSa41RetarderSpeedAtPeakTorquePoint5 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F7C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRcSa41RetarderSpeedAtPoint3 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F78 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRcSa41RetarderSpeedAtPoint4 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F74 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRxBMSCelInforSa243RxBatMaxCellTemp "SWTST_f32ComRdRxBMSCelInforSa243RxBatMaxCellTemp" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F70 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRxBMSCelInforSa243RxBatMaxCellVoltg "SWTST_f32ComRdRxBMSCelInforSa243RxBatMaxCellVoltg" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F6C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRxBMSCelInforSa243RxBatMinCellTemp "SWTST_f32ComRdRxBMSCelInforSa243RxBatMinCellTemp" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F68 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRxBMSCelInforSa243RxBatMinCellVoltg "SWTST_f32ComRdRxBMSCelInforSa243RxBatMinCellVoltg" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F64 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRxBMSCelInforSa243RxBatSystCellVoltgDiff "SWTST_f32ComRdRxBMSCelInforSa243RxBatSystCellVoltgDiff" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F60 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRxBMSFailSa243RxBMSCANVersion "SWTST_f32ComRdRxBMSFailSa243RxBMSCANVersion" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F5C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRxBMSMainParaSa243RxBatSOC "SWTST_f32ComRdRxBMSMainParaSa243RxBatSOC" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F58 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRxBMSMainParaSa243RxBatTotalCurrent "SWTST_f32ComRdRxBMSMainParaSa243RxBatTotalCurrent" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F54 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRxBMSMainParaSa243RxBatTotalVoltage "SWTST_f32ComRdRxBMSMainParaSa243RxBatTotalVoltage" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F50 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRxBrkPumpCtrlSa155Da255RxBrkPumpCtrlBusVolt "SWTST_f32ComRdRxBrkPumpCtrlSa155Da255RxBrkPumpCtrlBusVolt" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F4C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRxBrkPumpCtrlSa155Da255RxBrkPumpCtrlSpdMot "SWTST_f32ComRdRxBrkPumpCtrlSa155Da255RxBrkPumpCtrlSpdMot" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F48 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRxBrkPumpCtrlSa155Da255RxBrkPumpCtrlTemp "SWTST_f32ComRdRxBrkPumpCtrlSa155Da255RxBrkPumpCtrlTemp" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F44 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRxDBStaVehSa23RxDBBacBraPres "SWTST_f32ComRdRxDBStaVehSa23RxDBBacBraPres" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F40 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRxDBStaVehSa23RxDBBatVoltage "SWTST_f32ComRdRxDBStaVehSa23RxDBBatVoltage" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F3C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRxDBStaVehSa23RxDBFroBraPres "SWTST_f32ComRdRxDBStaVehSa23RxDBFroBraPres" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F38 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRxDCDCCtrl1Sa243RxDCDCCtrl1OutputCurrent "SWTST_f32ComRdRxDCDCCtrl1Sa243RxDCDCCtrl1OutputCurrent" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F34 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRxDCDCCtrl1Sa243RxDCDCCtrl1OutputVolt "SWTST_f32ComRdRxDCDCCtrl1Sa243RxDCDCCtrl1OutputVolt" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F30 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRxDCDCCtrl1Sa243RxDCDCCtrl1Temp "SWTST_f32ComRdRxDCDCCtrl1Sa243RxDCDCCtrl1Temp" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F2C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRxMCUStatus1Sa08RxMCUMotACCurrent "SWTST_f32ComRdRxMCUStatus1Sa08RxMCUMotACCurrent" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F28 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRxMCUStatus1Sa08RxMCUMotSpd "SWTST_f32ComRdRxMCUStatus1Sa08RxMCUMotSpd" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F24 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRxMCUStatus1Sa08RxMCUMotTrq "SWTST_f32ComRdRxMCUStatus1Sa08RxMCUMotTrq" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F20 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRxMCUStatus2Sa08RxMCUMotControllerTemp "SWTST_f32ComRdRxMCUStatus2Sa08RxMCUMotControllerTemp" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F1C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRxMCUStatus2Sa08RxMCUMotMinTrqLmt "SWTST_f32ComRdRxMCUStatus2Sa08RxMCUMotMinTrqLmt" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F18 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRxMCUStatus2Sa08RxMCUMotTemp "SWTST_f32ComRdRxMCUStatus2Sa08RxMCUMotTemp" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F14 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRxMCUStatus3Sa08RxMCUDCCurr "SWTST_f32ComRdRxMCUStatus3Sa08RxMCUDCCurr" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F10 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRxMCUStatus3Sa08RxMCUDCVolt "SWTST_f32ComRdRxMCUStatus3Sa08RxMCUDCVolt" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F0C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRxSteerPumpCtrlSa149Da255RxSteerPumpCtrlBusVolt "SWTST_f32ComRdRxSteerPumpCtrlSa149Da255RxSteerPumpCtrlBusVolt" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F08 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRxSteerPumpCtrlSa149Da255RxSteerPumpCtrlSpdMot "SWTST_f32ComRdRxSteerPumpCtrlSa149Da255RxSteerPumpCtrlSpdMot" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F04 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdRxSteerPumpCtrlSa149Da255RxSteerPumpCtrlTemp "SWTST_f32ComRdRxSteerPumpCtrlSa149Da255RxSteerPumpCtrlTemp" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014F00 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTc1Sa05Da255RequestedPercentClutchSlip "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014EFC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTc1Sa05Da255TransRequestedGear "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014EF8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTc1Sa05RequestedPercentClutchSlip "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014EF4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTc1Sa05TransRequestedGear "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014EF0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTc1Sa06Da255RequestedPercentClutchSlip "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014EEC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTc1Sa06Da255TransRequestedGear "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014EE8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTc1Sa06RequestedPercentClutchSlip "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014EE4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTc1Sa06TransRequestedGear "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014EE0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTc1Sa23Da255RequestedPercentClutchSlip "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014EDC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTc1Sa23Da255TransRequestedGear "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014ED8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTc1Sa23RequestedPercentClutchSlip "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014ED4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTc1Sa23TransRequestedGear "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014ED0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTc1Sa33Da255RequestedPercentClutchSlip "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014ECC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTc1Sa33Da255TransRequestedGear "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014EC8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTc1Sa33RequestedPercentClutchSlip "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014EC4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTc1Sa33TransRequestedGear "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014EC0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTc1Sa42Da255RequestedPercentClutchSlip "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014EBC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTc1Sa42Da255TransRequestedGear "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014EB8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTc1Sa42RequestedPercentClutchSlip "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014EB4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTc1Sa42TransRequestedGear "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014EB0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTc1Sa49Da255RequestedPercentClutchSlip "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014EAC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTc1Sa49Da255TransRequestedGear "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014EA8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTc1Sa49RequestedPercentClutchSlip "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014EA4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTc1Sa49TransRequestedGear "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014EA0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTsc1Sa00EngRequestedSpeedSpeedLimit "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E9C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTsc1Sa00EngRequestedTorqueHighResolution "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E98 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTsc1Sa00EngRequestedTorqueTorqueLimit "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E94 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTsc1Sa11EngRequestedSpeedSpeedLimit "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E90 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTsc1Sa11EngRequestedTorqueHighResolution "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E8C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTsc1Sa11EngRequestedTorqueTorqueLimit "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E88 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTsc1Sa17EngRequestedSpeedSpeedLimit "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E84 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTsc1Sa17EngRequestedTorqueHighResolution "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E80 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTsc1Sa17EngRequestedTorqueTorqueLimit "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E7C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTsc1Sa33EngRequestedSpeedSpeedLimit "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E78 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTsc1Sa33EngRequestedTorqueHighResolution "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E74 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTsc1Sa33EngRequestedTorqueTorqueLimit "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E70 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTsc1Sa39EngRequestedSpeedSpeedLimit "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E6C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTsc1Sa39EngRequestedTorqueHighResolution "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E68 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTsc1Sa39EngRequestedTorqueTorqueLimit "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E64 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTsc1Sa42EngRequestedSpeedSpeedLimit "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E60 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTsc1Sa42EngRequestedTorqueHighResolution "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E5C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32ComRdTsc1Sa42EngRequestedTorqueTorqueLimit "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E58 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32Swc5VSply1 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E54 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32Swc5VSply2 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E50 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32Swc9VSply1 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E4C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_1_1_AvgCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E48 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_1_1_DitherAmplFb "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E44 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_1_1_DitherFrqFb "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E40 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_1_1_MaxCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E3C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_1_1_MinCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E38 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_1_1_PwmDutyFb "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E34 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_1_2_AvgCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E30 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_1_2_DitherAmplFb "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E2C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_1_2_DitherFrqFb "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E28 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_1_2_MaxCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E24 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_1_2_MinCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E20 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_1_2_PwmDutyFb "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E1C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_2_3_AvgCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E18 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_2_3_DitherAmplFb "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E14 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_2_3_DitherFrqFb "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E10 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_2_3_MaxCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E0C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_2_3_MinCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E08 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_2_3_PwmDutyFb "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E04 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_2_4_AvgCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014E00 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_2_4_DitherAmplFb "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014DFC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_2_4_DitherFrqFb "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014DF8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_2_4_MaxCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014DF4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_2_4_MinCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014DF0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_2_4_PwmDutyFb "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014DEC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_2_5_AvgCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014DE8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_2_5_DitherAmplFb "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014DE4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_2_5_DitherFrqFb "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014DE0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_2_5_MaxCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014DDC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_2_5_MinCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014DD8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_2_5_PwmDutyFb "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014DD4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_3_6_AvgCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014DD0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_3_6_DitherAmplFb "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014DCC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_3_6_DitherFrqFb "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014DC8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_3_6_MaxCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014DC4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_3_6_MinCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014DC0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_3_6_PwmDutyFb "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014DBC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_3_7_AvgCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014DB8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_3_7_DitherAmplFb "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014DB4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_3_7_DitherFrqFb "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014DB0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_3_7_MaxCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014DAC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_3_7_MinCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014DA8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_3_7_PwmDutyFb "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014DA4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_3_8_AvgCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014DA0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_3_8_DitherAmplFb "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D9C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_3_8_DitherFrqFb "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D98 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_3_8_MaxCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D94 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_3_8_MinCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D90 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_3_8_PwmDutyFb "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D8C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_4_10_AvgCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D88 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_4_10_DitherAmplFb "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D84 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_4_10_DitherFrqFb "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D80 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_4_10_MaxCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D7C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_4_10_MinCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D78 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_4_10_PwmDutyFb "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D74 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_4_9_AvgCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D70 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_4_9_DitherAmplFb "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D6C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_4_9_DitherFrqFb "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D68 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_4_9_MaxCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D64 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_4_9_MinCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D60 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_LINEAR_VALVE_4_9_PwmDutyFb "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D5C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_PWM_VALVE_1_1_AvgCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D58 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_PWM_VALVE_1_1_DitherAmplFb "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D54 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_PWM_VALVE_1_1_DitherFrqFb "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D50 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_PWM_VALVE_1_1_MaxCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D4C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_PWM_VALVE_1_1_MinCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D48 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_PWM_VALVE_1_1_PwmDutyFb "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D44 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_PWM_VALVE_1_2_AvgCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D40 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_PWM_VALVE_1_2_DitherAmplFb "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D3C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_PWM_VALVE_1_2_DitherFrqFb "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D38 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_PWM_VALVE_1_2_MaxCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D34 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_PWM_VALVE_1_2_MinCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D30 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_PWM_VALVE_1_2_PwmDutyFb "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D2C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_PWM_VALVE_1_3_AvgCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D28 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_PWM_VALVE_1_3_DitherAmplFb "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D24 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_PWM_VALVE_1_3_DitherFrqFb "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D20 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_PWM_VALVE_1_3_MaxCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D1C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_PWM_VALVE_1_3_MinCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D18 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_PWM_VALVE_1_3_PwmDutyFb "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D14 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_PWM_VALVE_4_4_AvgCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D10 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_PWM_VALVE_4_4_DitherAmplFb "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D0C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_PWM_VALVE_4_4_DitherFrqFb "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D08 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_PWM_VALVE_4_4_MaxCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D04 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_PWM_VALVE_4_4_MinCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014D00 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_PWM_VALVE_4_4_PwmDutyFb "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014CFC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_PWM_VALVE_4_5_AvgCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014CF8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_PWM_VALVE_4_5_DitherAmplFb "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014CF4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_PWM_VALVE_4_5_DitherFrqFb "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014CF0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_PWM_VALVE_4_5_MaxCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014CEC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_PWM_VALVE_4_5_MinCrnt "value" FLOAT32_IEEE F_1_p1_28 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014CE8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32TLE8242_PWM_VALVE_4_5_PwmDutyFb "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014CE4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32Tle8242ReadPwmFrqLnrVlv1_1 "SWTST_f32Tle8242ReadPwmFrqLnrVlv1_1" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014CE0 /end MEASUREMENT
/begin MEASUREMENT SWTST_f32Tle8242ReadPwmFrqLnrVlv1_2 "SWTST_f32Tle8242ReadPwmFrqLnrVlv1_2" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014CDC /end MEASUREMENT
/begin MEASUREMENT SWTST_f32Tle8242ReadPwmFrqLnrVlv2_3 "SWTST_f32Tle8242ReadPwmFrqLnrVlv2_3" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014CD8 /end MEASUREMENT
/begin MEASUREMENT SWTST_f32Tle8242ReadPwmFrqLnrVlv2_4 "SWTST_f32Tle8242ReadPwmFrqLnrVlv2_4" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014CD4 /end MEASUREMENT
/begin MEASUREMENT SWTST_f32Tle8242ReadPwmFrqLnrVlv2_5 "SWTST_f32Tle8242ReadPwmFrqLnrVlv2_5" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014CD0 /end MEASUREMENT
/begin MEASUREMENT SWTST_f32Tle8242ReadPwmFrqLnrVlv3_6 "SWTST_f32Tle8242ReadPwmFrqLnrVlv3_6" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014CCC /end MEASUREMENT
/begin MEASUREMENT SWTST_f32Tle8242ReadPwmFrqLnrVlv3_7 "SWTST_f32Tle8242ReadPwmFrqLnrVlv3_7" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014CC8 /end MEASUREMENT
/begin MEASUREMENT SWTST_f32Tle8242ReadPwmFrqLnrVlv3_8 "SWTST_f32Tle8242ReadPwmFrqLnrVlv3_8" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014CC4 /end MEASUREMENT
/begin MEASUREMENT SWTST_f32Tle8242ReadPwmFrqLnrVlv4_10 "SWTST_f32Tle8242ReadPwmFrqLnrVlv4_10" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014CC0 /end MEASUREMENT
/begin MEASUREMENT SWTST_f32Tle8242ReadPwmFrqLnrVlv4_9 "SWTST_f32Tle8242ReadPwmFrqLnrVlv4_9" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014CBC /end MEASUREMENT
/begin MEASUREMENT SWTST_f32Tle8242ReadPwmFrqPwmVlv1_1 "SWTST_f32Tle8242ReadPwmFrqPwmVlv1_1" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014CB8 /end MEASUREMENT
/begin MEASUREMENT SWTST_f32Tle8242ReadPwmFrqPwmVlv1_2 "SWTST_f32Tle8242ReadPwmFrqPwmVlv1_2" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014CB4 /end MEASUREMENT
/begin MEASUREMENT SWTST_f32Tle8242ReadPwmFrqPwmVlv1_3 "SWTST_f32Tle8242ReadPwmFrqPwmVlv1_3" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014CB0 /end MEASUREMENT
/begin MEASUREMENT SWTST_f32Tle8242ReadPwmFrqPwmVlv4_4 "SWTST_f32Tle8242ReadPwmFrqPwmVlv4_4" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014CAC /end MEASUREMENT
/begin MEASUREMENT SWTST_f32Tle8242ReadPwmFrqPwmVlv4_5 "SWTST_f32Tle8242ReadPwmFrqPwmVlv4_5" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014CA8 /end MEASUREMENT
/begin MEASUREMENT SWTST_f32Tle8242WrPwmFrqLnrVlv1_1 "SWTST_f32Tle8242WrPwmFrqLnrVlv1_1" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014CA4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32Tle8242WrPwmFrqLnrVlv1_2 "SWTST_f32Tle8242WrPwmFrqLnrVlv1_2" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014CA0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32Tle8242WrPwmFrqLnrVlv2_3 "SWTST_f32Tle8242WrPwmFrqLnrVlv2_3" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C9C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32Tle8242WrPwmFrqLnrVlv2_4 "SWTST_f32Tle8242WrPwmFrqLnrVlv2_4" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C98 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32Tle8242WrPwmFrqLnrVlv2_5 "SWTST_f32Tle8242WrPwmFrqLnrVlv2_5" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C94 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32Tle8242WrPwmFrqLnrVlv3_6 "SWTST_f32Tle8242WrPwmFrqLnrVlv3_6" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C90 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32Tle8242WrPwmFrqLnrVlv3_7 "SWTST_f32Tle8242WrPwmFrqLnrVlv3_7" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C8C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32Tle8242WrPwmFrqLnrVlv3_8 "SWTST_f32Tle8242WrPwmFrqLnrVlv3_8" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C88 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32Tle8242WrPwmFrqLnrVlv4_10 "SWTST_f32Tle8242WrPwmFrqLnrVlv4_10" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C84 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32Tle8242WrPwmFrqLnrVlv4_9 "SWTST_f32Tle8242WrPwmFrqLnrVlv4_9" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C80 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32Tle8242WrPwmFrqPwmVlv1_1 "SWTST_f32Tle8242WrPwmFrqPwmVlv1_1" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C7C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32Tle8242WrPwmFrqPwmVlv1_2 "SWTST_f32Tle8242WrPwmFrqPwmVlv1_2" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C78 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32Tle8242WrPwmFrqPwmVlv1_3 "SWTST_f32Tle8242WrPwmFrqPwmVlv1_3" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C74 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32Tle8242WrPwmFrqPwmVlv4_4 "SWTST_f32Tle8242WrPwmFrqPwmVlv4_4" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C70 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_f32Tle8242WrPwmFrqPwmVlv4_5 "SWTST_f32Tle8242WrPwmFrqPwmVlv4_5" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C6C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_kbPwdTstEnaC "Activate Dio tests" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60012518 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_ku8ComWrCiSa03CptIdnLen "SWTST_ku8ComWrCiSa03CptIdnLen" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012517 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_ku8ComWrSoftLen "SWTST_ku8ComWrSoftLen" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60012516 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdAnDiagHsSw12 "SWTST_s16RdAnDiagHsSw12" SWORD F_0v0012207031_p0_12 1 2 -40 39.9987793 ECU_ADDRESS 0x60010ED0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdAnDiagHsSw34 "SWTST_s16RdAnDiagHsSw34" SWORD F_0v0012207031_p0_12 1 2 -40 39.9987793 ECU_ADDRESS 0x60010ECE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdAnDiagSolSw1 "SWTST_s16RdAnDiagSolSw1" SWORD F_0v0012207031_p0_12 1 2 -40 39.9987793 ECU_ADDRESS 0x60010ECC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdAnDiagSolSw2 "SWTST_s16RdAnDiagSolSw2" SWORD F_0v0012207031_p0_12 1 2 -40 39.9987793 ECU_ADDRESS 0x60010ECA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdAnDiagSolSw3 "SWTST_s16RdAnDiagSolSw3" SWORD F_0v0012207031_p0_12 1 2 -40 39.9987793 ECU_ADDRESS 0x60010EC8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdAnDiagSolSw4 "SWTST_s16RdAnDiagSolSw4" SWORD F_0v0012207031_p0_12 1 2 -40 39.9987793 ECU_ADDRESS 0x60010EC6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdAnEngSpdHall "SWTST_s16RdAnEngSpdHall" SWORD F_0v0012207031_p0_12 1 2 -40 39.9987793 ECU_ADDRESS 0x60010EC4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdAnEngSpdVr "SWTST_s16RdAnEngSpdVr" SWORD F_0v0012207031_p0_12 1 2 -40 39.9987793 ECU_ADDRESS 0x60010EC2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdAnInAnlgTemp1 "SWTST_s16RdAnInAnlgTemp1" SWORD F_0v0012207031_p0_12 1 2 -40 39.9987793 ECU_ADDRESS 0x60010EC0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdAnInAnlgTemp2 "SWTST_s16RdAnInAnlgTemp2" SWORD F_0v0012207031_p0_12 1 2 -40 39.9987793 ECU_ADDRESS 0x60010EBE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdAnInAnlgTemp3 "SWTST_s16RdAnInAnlgTemp3" SWORD F_0v0012207031_p0_12 1 2 -40 39.9987793 ECU_ADDRESS 0x60010EBC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdAnInAnlgVolt1 "SWTST_s16RdAnInAnlgVolt1" SWORD F_0v0012207031_p0_12 1 2 -40 39.9987793 ECU_ADDRESS 0x60010EBA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdAnInAnlgVolt2 "SWTST_s16RdAnInAnlgVolt2" SWORD F_0v0012207031_p0_12 1 2 -40 39.9987793 ECU_ADDRESS 0x60010EB8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdAnInAnlgVolt3 "SWTST_s16RdAnInAnlgVolt3" SWORD F_0v0012207031_p0_12 1 2 -40 39.9987793 ECU_ADDRESS 0x60010EB6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdAnInAnlgVolt4 "SWTST_s16RdAnInAnlgVolt4" SWORD F_0v0012207031_p0_12 1 2 -40 39.9987793 ECU_ADDRESS 0x60010EB4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdAnInAnlgVolt5 "SWTST_s16RdAnInAnlgVolt5" SWORD F_0v0012207031_p0_12 1 2 -40 39.9987793 ECU_ADDRESS 0x60010EB2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdAnInAnlgVolt6 "SWTST_s16RdAnInAnlgVolt6" SWORD F_0v0012207031_p0_12 1 2 -40 39.9987793 ECU_ADDRESS 0x60010EB0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdAnInputSpdHall "SWTST_s16RdAnInputSpdHall" SWORD F_0v0012207031_p0_12 1 2 -40 39.9987793 ECU_ADDRESS 0x60010EAE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdAnIptSpdVr "SWTST_s16RdAnIptSpdVr" SWORD F_0v0012207031_p0_12 1 2 -40 39.9987793 ECU_ADDRESS 0x60010EAC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdAnOutSpdVr "SWTST_s16RdAnOutSpdVr" SWORD F_0v0012207031_p0_12 1 2 -40 39.9987793 ECU_ADDRESS 0x60010EA8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdAnOutputSpdHall "SWTST_s16RdAnOutputSpdHall" SWORD F_0v0012207031_p0_12 1 2 -40 39.9987793 ECU_ADDRESS 0x60010EAA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdAnP5vSnsSup1 "SWTST_s16RdAnP5vSnsSup1" SWORD F_0v0012207031_p0_12 1 2 -40 39.9987793 ECU_ADDRESS 0x60010EA6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdAnP5vSnsSup2 "SWTST_s16RdAnP5vSnsSup2" SWORD F_0v0012207031_p0_12 1 2 -40 39.9987793 ECU_ADDRESS 0x60010EA4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdAnP9vSensSup21 "SWTST_s16RdAnP9vSensSup21" SWORD F_0v0012207031_p0_12 1 2 -40 39.9987793 ECU_ADDRESS 0x60010EA2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdAnP9vSensSup22 "SWTST_s16RdAnP9vSensSup22" SWORD F_0v0012207031_p0_12 1 2 -40 39.9987793 ECU_ADDRESS 0x60010EA0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdAnP9vSnsSup1 "SWTST_s16RdAnP9vSnsSup1" SWORD F_0v0012207031_p0_12 1 2 -40 39.9987793 ECU_ADDRESS 0x60010E9E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdAnPwmIn1 "SWTST_s16RdAnPwmIn1" SWORD F_0v0012207031_p0_12 1 2 -40 39.9987793 ECU_ADDRESS 0x60010E9C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdAnPwmIn2 "SWTST_s16RdAnPwmIn2" SWORD F_0v0012207031_p0_12 1 2 -40 39.9987793 ECU_ADDRESS 0x60010E9A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdAnTmpPcb "SWTST_s16RdAnTmpPcb" SWORD F_0v0012207031_p0_12 1 2 -40 39.9987793 ECU_ADDRESS 0x60010E98 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdAnVbatKL30SwSup "SWTST_s16RdAnVbatKL30SwSup" SWORD F_0v0012207031_p0_12 1 2 -40 39.9987793 ECU_ADDRESS 0x60010E96 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdAnVbatPSwSup "SWTST_s16RdAnVbatPSwSup" SWORD F_0v0012207031_p0_12 1 2 -40 39.9987793 ECU_ADDRESS 0x60010E94 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdAnVcc5vSup "SWTST_s16RdAnVcc5vSup" SWORD F_0v0012207031_p0_12 1 2 -40 39.9987793 ECU_ADDRESS 0x60010E92 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdP5vSnsSup1 "SWTST_s16RdAnP5vSnsSup1" SWORD F_0v00244_p0_30 1 2 -79.95392 79.95148 ECU_ADDRESS 0x60010EA6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdP5vSnsSup2 "SWTST_s16RdAnP5vSnsSup2" SWORD F_0v00244_p0_30 1 2 -79.95392 79.95148 ECU_ADDRESS 0x60010EA4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdP9vSensSup21 "SWTST_s16RdAnP9vSensSup21" SWORD F_0v0043883505_p0_31 1 2 -143.7974684 143.79308 ECU_ADDRESS 0x60010EA2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdP9vSensSup22 "SWTST_s16RdAnP9vSensSup22" SWORD F_0v0043883505_p0_31 1 2 -143.7974684 143.79308 ECU_ADDRESS 0x60010EA0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdP9vSnsSup1 "SWTST_s16RdAnP9vSnsSup1" SWORD F_0v0043883505_p0_31 1 2 -143.7974684 143.79308 ECU_ADDRESS 0x60010E9E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdPhysTmpMicro "SWTST_s16RdPhysTmpMicro" SWORD F_0v0625_p0_32 1 2 -2048 2047.9375 ECU_ADDRESS 0x60010E90 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdPhysTmpPcb "SWTST_s16RdPhysTmpPcb" SWORD F_0v0625_p0_32 1 2 -2048 2047.9375 ECU_ADDRESS 0x60010E8E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdVbatKL30SwSup "SWTST_s16RdAnVbatKL30SwSup" SWORD F_0v0134277344_p0_33 1 2 -440 439.9865723 ECU_ADDRESS 0x60010E96 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdVbatPSwSup "SWTST_s16RdAnVbatPSwSup" SWORD F_0v0134277344_p0_33 1 2 -440 439.9865723 ECU_ADDRESS 0x60010E94 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_s16RdVcc5vSup "SWTST_s16RdAnVcc5vSup" SWORD F_0v00244_p0_30 1 2 -79.95392 79.95148 ECU_ADDRESS 0x60010E92 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u16ComRdRxMCUStatus2Sa08RxMCUMotMaxTrqLmt "SWTST_u16ComRdRxMCUStatus2Sa08RxMCUMotMaxTrqLmt" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E6C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242ReadKiLnrVlv1_1 "SWTST_u16Tle8242ReadKiLnrVlv1_1" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E6A /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242ReadKiLnrVlv1_2 "SWTST_u16Tle8242ReadKiLnrVlv1_2" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E68 /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242ReadKiLnrVlv2_3 "SWTST_u16Tle8242ReadKiLnrVlv2_3" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E66 /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242ReadKiLnrVlv2_4 "SWTST_u16Tle8242ReadKiLnrVlv2_4" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E64 /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242ReadKiLnrVlv2_5 "SWTST_u16Tle8242ReadKiLnrVlv2_5" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E62 /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242ReadKiLnrVlv3_6 "SWTST_u16Tle8242ReadKiLnrVlv3_6" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E60 /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242ReadKiLnrVlv3_7 "SWTST_u16Tle8242ReadKiLnrVlv3_7" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E5E /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242ReadKiLnrVlv3_8 "SWTST_u16Tle8242ReadKiLnrVlv3_8" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E5C /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242ReadKiLnrVlv4_10 "SWTST_u16Tle8242ReadKiLnrVlv4_10" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E5A /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242ReadKiLnrVlv4_9 "SWTST_u16Tle8242ReadKiLnrVlv4_9" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E58 /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242ReadKiPwmVlv1_1 "SWTST_u16Tle8242ReadKiPwmVlv1_1" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E56 /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242ReadKiPwmVlv1_2 "SWTST_u16Tle8242ReadKiPwmVlv1_2" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E54 /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242ReadKiPwmVlv1_3 "SWTST_u16Tle8242ReadKiPwmVlv1_3" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E52 /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242ReadKiPwmVlv4_4 "SWTST_u16Tle8242ReadKiPwmVlv4_4" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E50 /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242ReadKiPwmVlv4_5 "SWTST_u16Tle8242ReadKiPwmVlv4_5" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E4E /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242ReadKpLnrVlv1_1 "SWTST_u16Tle8242ReadKpLnrVlv1_1" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E4C /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242ReadKpLnrVlv1_2 "SWTST_u16Tle8242ReadKpLnrVlv1_2" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E4A /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242ReadKpLnrVlv2_3 "SWTST_u16Tle8242ReadKpLnrVlv2_3" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E48 /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242ReadKpLnrVlv2_4 "SWTST_u16Tle8242ReadKpLnrVlv2_4" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E46 /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242ReadKpLnrVlv2_5 "SWTST_u16Tle8242ReadKpLnrVlv2_5" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E44 /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242ReadKpLnrVlv3_6 "SWTST_u16Tle8242ReadKpLnrVlv3_6" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E42 /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242ReadKpLnrVlv3_7 "SWTST_u16Tle8242ReadKpLnrVlv3_7" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E40 /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242ReadKpLnrVlv3_8 "SWTST_u16Tle8242ReadKpLnrVlv3_8" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E3E /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242ReadKpLnrVlv4_10 "SWTST_u16Tle8242ReadKpLnrVlv4_10" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E3C /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242ReadKpLnrVlv4_9 "SWTST_u16Tle8242ReadKpLnrVlv4_9" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E3A /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242ReadKpPwmVlv1_1 "SWTST_u16Tle8242ReadKpPwmVlv1_1" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E38 /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242ReadKpPwmVlv1_2 "SWTST_u16Tle8242ReadKpPwmVlv1_2" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E36 /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242ReadKpPwmVlv1_3 "SWTST_u16Tle8242ReadKpPwmVlv1_3" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E34 /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242ReadKpPwmVlv4_4 "SWTST_u16Tle8242ReadKpPwmVlv4_4" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E32 /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242ReadKpPwmVlv4_5 "SWTST_u16Tle8242ReadKpPwmVlv4_5" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E30 /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242WrKiLnrVlv1_1 "SWTST_u16Tle8242WrKiLnrVlv1_1" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E2E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242WrKiLnrVlv1_2 "SWTST_u16Tle8242WrKiLnrVlv1_2" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E2C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242WrKiLnrVlv2_3 "SWTST_u16Tle8242WrKiLnrVlv2_3" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E2A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242WrKiLnrVlv2_4 "SWTST_u16Tle8242WrKiLnrVlv2_4" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E28 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242WrKiLnrVlv2_5 "SWTST_u16Tle8242WrKiLnrVlv2_5" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E26 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242WrKiLnrVlv3_6 "SWTST_u16Tle8242WrKiLnrVlv3_6" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E24 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242WrKiLnrVlv3_7 "SWTST_u16Tle8242WrKiLnrVlv3_7" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E22 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242WrKiLnrVlv3_8 "SWTST_u16Tle8242WrKiLnrVlv3_8" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E20 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242WrKiLnrVlv4_10 "SWTST_u16Tle8242WrKiLnrVlv4_10" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E1E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242WrKiLnrVlv4_9 "SWTST_u16Tle8242WrKiLnrVlv4_9" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E1C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242WrKiPwmVlv1_1 "SWTST_u16Tle8242WrKiPwmVlv1_1" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E1A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242WrKiPwmVlv1_2 "SWTST_u16Tle8242WrKiPwmVlv1_2" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E18 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242WrKiPwmVlv1_3 "SWTST_u16Tle8242WrKiPwmVlv1_3" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E16 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242WrKiPwmVlv4_4 "SWTST_u16Tle8242WrKiPwmVlv4_4" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E14 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242WrKiPwmVlv4_5 "SWTST_u16Tle8242WrKiPwmVlv4_5" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E12 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242WrKpLnrVlv1_1 "SWTST_u16Tle8242WrKpLnrVlv1_1" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E10 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242WrKpLnrVlv1_2 "SWTST_u16Tle8242WrKpLnrVlv1_2" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E0E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242WrKpLnrVlv2_3 "SWTST_u16Tle8242WrKpLnrVlv2_3" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E0C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242WrKpLnrVlv2_4 "SWTST_u16Tle8242WrKpLnrVlv2_4" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E0A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242WrKpLnrVlv2_5 "SWTST_u16Tle8242WrKpLnrVlv2_5" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E08 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242WrKpLnrVlv3_6 "SWTST_u16Tle8242WrKpLnrVlv3_6" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E06 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242WrKpLnrVlv3_7 "SWTST_u16Tle8242WrKpLnrVlv3_7" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E04 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242WrKpLnrVlv3_8 "SWTST_u16Tle8242WrKpLnrVlv3_8" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E02 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242WrKpLnrVlv4_10 "SWTST_u16Tle8242WrKpLnrVlv4_10" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010E00 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242WrKpLnrVlv4_9 "SWTST_u16Tle8242WrKpLnrVlv4_9" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010DFE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242WrKpPwmVlv1_1 "SWTST_u16Tle8242WrKpPwmVlv1_1" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010DFC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242WrKpPwmVlv1_2 "SWTST_u16Tle8242WrKpPwmVlv1_2" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010DFA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242WrKpPwmVlv1_3 "SWTST_u16Tle8242WrKpPwmVlv1_3" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010DF8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242WrKpPwmVlv4_4 "SWTST_u16Tle8242WrKpPwmVlv4_4" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010DF6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u16Tle8242WrKpPwmVlv4_5 "SWTST_u16Tle8242WrKpPwmVlv4_5" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010DF4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32AdcTstErrInfo "Information on the error that stopped the sequence" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014828 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0 "SWTST_u32CalibTst0" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 100 1 1 ECU_ADDRESS 0x60014698 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[0] "SWTST_u32CalibTst0[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014698 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[10] "SWTST_u32CalibTst0[10]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600146C0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[11] "SWTST_u32CalibTst0[11]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600146C4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[12] "SWTST_u32CalibTst0[12]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600146C8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[13] "SWTST_u32CalibTst0[13]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600146CC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[14] "SWTST_u32CalibTst0[14]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600146D0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[15] "SWTST_u32CalibTst0[15]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600146D4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[16] "SWTST_u32CalibTst0[16]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600146D8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[17] "SWTST_u32CalibTst0[17]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600146DC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[18] "SWTST_u32CalibTst0[18]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600146E0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[19] "SWTST_u32CalibTst0[19]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600146E4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[1] "SWTST_u32CalibTst0[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001469C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[20] "SWTST_u32CalibTst0[20]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600146E8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[21] "SWTST_u32CalibTst0[21]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600146EC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[22] "SWTST_u32CalibTst0[22]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600146F0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[23] "SWTST_u32CalibTst0[23]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600146F4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[24] "SWTST_u32CalibTst0[24]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600146F8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[25] "SWTST_u32CalibTst0[25]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600146FC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[26] "SWTST_u32CalibTst0[26]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014700 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[27] "SWTST_u32CalibTst0[27]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014704 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[28] "SWTST_u32CalibTst0[28]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014708 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[29] "SWTST_u32CalibTst0[29]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001470C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[2] "SWTST_u32CalibTst0[2]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600146A0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[30] "SWTST_u32CalibTst0[30]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014710 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[31] "SWTST_u32CalibTst0[31]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014714 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[32] "SWTST_u32CalibTst0[32]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014718 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[33] "SWTST_u32CalibTst0[33]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001471C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[34] "SWTST_u32CalibTst0[34]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014720 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[35] "SWTST_u32CalibTst0[35]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014724 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[36] "SWTST_u32CalibTst0[36]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014728 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[37] "SWTST_u32CalibTst0[37]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001472C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[38] "SWTST_u32CalibTst0[38]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014730 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[39] "SWTST_u32CalibTst0[39]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014734 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[3] "SWTST_u32CalibTst0[3]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600146A4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[40] "SWTST_u32CalibTst0[40]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014738 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[41] "SWTST_u32CalibTst0[41]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001473C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[42] "SWTST_u32CalibTst0[42]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014740 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[43] "SWTST_u32CalibTst0[43]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014744 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[44] "SWTST_u32CalibTst0[44]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014748 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[45] "SWTST_u32CalibTst0[45]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001474C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[46] "SWTST_u32CalibTst0[46]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014750 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[47] "SWTST_u32CalibTst0[47]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014754 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[48] "SWTST_u32CalibTst0[48]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014758 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[49] "SWTST_u32CalibTst0[49]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001475C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[4] "SWTST_u32CalibTst0[4]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600146A8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[50] "SWTST_u32CalibTst0[50]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014760 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[51] "SWTST_u32CalibTst0[51]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014764 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[52] "SWTST_u32CalibTst0[52]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014768 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[53] "SWTST_u32CalibTst0[53]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001476C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[54] "SWTST_u32CalibTst0[54]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014770 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[55] "SWTST_u32CalibTst0[55]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014774 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[56] "SWTST_u32CalibTst0[56]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014778 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[57] "SWTST_u32CalibTst0[57]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001477C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[58] "SWTST_u32CalibTst0[58]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014780 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[59] "SWTST_u32CalibTst0[59]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014784 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[5] "SWTST_u32CalibTst0[5]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600146AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[60] "SWTST_u32CalibTst0[60]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014788 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[61] "SWTST_u32CalibTst0[61]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001478C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[62] "SWTST_u32CalibTst0[62]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014790 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[63] "SWTST_u32CalibTst0[63]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014794 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[64] "SWTST_u32CalibTst0[64]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014798 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[65] "SWTST_u32CalibTst0[65]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001479C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[66] "SWTST_u32CalibTst0[66]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600147A0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[67] "SWTST_u32CalibTst0[67]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600147A4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[68] "SWTST_u32CalibTst0[68]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600147A8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[69] "SWTST_u32CalibTst0[69]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600147AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[6] "SWTST_u32CalibTst0[6]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600146B0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[70] "SWTST_u32CalibTst0[70]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600147B0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[71] "SWTST_u32CalibTst0[71]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600147B4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[72] "SWTST_u32CalibTst0[72]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600147B8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[73] "SWTST_u32CalibTst0[73]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600147BC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[74] "SWTST_u32CalibTst0[74]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600147C0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[75] "SWTST_u32CalibTst0[75]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600147C4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[76] "SWTST_u32CalibTst0[76]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600147C8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[77] "SWTST_u32CalibTst0[77]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600147CC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[78] "SWTST_u32CalibTst0[78]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600147D0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[79] "SWTST_u32CalibTst0[79]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600147D4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[7] "SWTST_u32CalibTst0[7]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600146B4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[80] "SWTST_u32CalibTst0[80]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600147D8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[81] "SWTST_u32CalibTst0[81]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600147DC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[82] "SWTST_u32CalibTst0[82]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600147E0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[83] "SWTST_u32CalibTst0[83]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600147E4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[84] "SWTST_u32CalibTst0[84]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600147E8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[85] "SWTST_u32CalibTst0[85]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600147EC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[86] "SWTST_u32CalibTst0[86]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600147F0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[87] "SWTST_u32CalibTst0[87]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600147F4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[88] "SWTST_u32CalibTst0[88]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600147F8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[89] "SWTST_u32CalibTst0[89]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600147FC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[8] "SWTST_u32CalibTst0[8]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600146B8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[90] "SWTST_u32CalibTst0[90]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014800 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[91] "SWTST_u32CalibTst0[91]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014804 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[92] "SWTST_u32CalibTst0[92]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014808 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[93] "SWTST_u32CalibTst0[93]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001480C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[94] "SWTST_u32CalibTst0[94]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014810 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[95] "SWTST_u32CalibTst0[95]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014814 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[96] "SWTST_u32CalibTst0[96]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014818 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[97] "SWTST_u32CalibTst0[97]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001481C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[98] "SWTST_u32CalibTst0[98]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014820 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[99] "SWTST_u32CalibTst0[99]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014824 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst0[9] "SWTST_u32CalibTst0[9]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600146BC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst1 "SWTST_u32CalibTst1" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 100 1 1 ECU_ADDRESS 0x60014508 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10 "SWTST_u32CalibTst10" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 100 1 1 ECU_ADDRESS 0x60014378 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[0] "SWTST_u32CalibTst10[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014378 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[10] "SWTST_u32CalibTst10[10]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600143A0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[11] "SWTST_u32CalibTst10[11]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600143A4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[12] "SWTST_u32CalibTst10[12]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600143A8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[13] "SWTST_u32CalibTst10[13]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600143AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[14] "SWTST_u32CalibTst10[14]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600143B0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[15] "SWTST_u32CalibTst10[15]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600143B4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[16] "SWTST_u32CalibTst10[16]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600143B8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[17] "SWTST_u32CalibTst10[17]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600143BC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[18] "SWTST_u32CalibTst10[18]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600143C0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[19] "SWTST_u32CalibTst10[19]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600143C4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[1] "SWTST_u32CalibTst10[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001437C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[20] "SWTST_u32CalibTst10[20]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600143C8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[21] "SWTST_u32CalibTst10[21]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600143CC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[22] "SWTST_u32CalibTst10[22]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600143D0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[23] "SWTST_u32CalibTst10[23]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600143D4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[24] "SWTST_u32CalibTst10[24]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600143D8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[25] "SWTST_u32CalibTst10[25]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600143DC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[26] "SWTST_u32CalibTst10[26]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600143E0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[27] "SWTST_u32CalibTst10[27]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600143E4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[28] "SWTST_u32CalibTst10[28]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600143E8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[29] "SWTST_u32CalibTst10[29]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600143EC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[2] "SWTST_u32CalibTst10[2]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014380 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[30] "SWTST_u32CalibTst10[30]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600143F0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[31] "SWTST_u32CalibTst10[31]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600143F4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[32] "SWTST_u32CalibTst10[32]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600143F8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[33] "SWTST_u32CalibTst10[33]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600143FC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[34] "SWTST_u32CalibTst10[34]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014400 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[35] "SWTST_u32CalibTst10[35]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014404 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[36] "SWTST_u32CalibTst10[36]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014408 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[37] "SWTST_u32CalibTst10[37]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001440C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[38] "SWTST_u32CalibTst10[38]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014410 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[39] "SWTST_u32CalibTst10[39]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014414 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[3] "SWTST_u32CalibTst10[3]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014384 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[40] "SWTST_u32CalibTst10[40]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014418 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[41] "SWTST_u32CalibTst10[41]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001441C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[42] "SWTST_u32CalibTst10[42]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014420 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[43] "SWTST_u32CalibTst10[43]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014424 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[44] "SWTST_u32CalibTst10[44]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014428 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[45] "SWTST_u32CalibTst10[45]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001442C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[46] "SWTST_u32CalibTst10[46]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014430 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[47] "SWTST_u32CalibTst10[47]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014434 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[48] "SWTST_u32CalibTst10[48]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014438 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[49] "SWTST_u32CalibTst10[49]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001443C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[4] "SWTST_u32CalibTst10[4]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014388 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[50] "SWTST_u32CalibTst10[50]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014440 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[51] "SWTST_u32CalibTst10[51]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014444 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[52] "SWTST_u32CalibTst10[52]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014448 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[53] "SWTST_u32CalibTst10[53]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001444C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[54] "SWTST_u32CalibTst10[54]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014450 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[55] "SWTST_u32CalibTst10[55]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014454 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[56] "SWTST_u32CalibTst10[56]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014458 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[57] "SWTST_u32CalibTst10[57]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001445C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[58] "SWTST_u32CalibTst10[58]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014460 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[59] "SWTST_u32CalibTst10[59]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014464 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[5] "SWTST_u32CalibTst10[5]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001438C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[60] "SWTST_u32CalibTst10[60]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014468 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[61] "SWTST_u32CalibTst10[61]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001446C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[62] "SWTST_u32CalibTst10[62]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014470 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[63] "SWTST_u32CalibTst10[63]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014474 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[64] "SWTST_u32CalibTst10[64]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014478 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[65] "SWTST_u32CalibTst10[65]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001447C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[66] "SWTST_u32CalibTst10[66]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014480 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[67] "SWTST_u32CalibTst10[67]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014484 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[68] "SWTST_u32CalibTst10[68]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014488 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[69] "SWTST_u32CalibTst10[69]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001448C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[6] "SWTST_u32CalibTst10[6]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014390 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[70] "SWTST_u32CalibTst10[70]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014490 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[71] "SWTST_u32CalibTst10[71]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014494 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[72] "SWTST_u32CalibTst10[72]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60014498 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_u32CalibTst10[73] "SWTST_u32CalibTst10[73]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6001449C READ_WRITE /end MEASUREMENT
/begin COMPU_METHOD I_5 "" RAT_FUNC "%9.2" "-" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD F_0v0012207031_p0_12 "" RAT_FUNC "%9.3" "V" COEFFS 0 1 0 0 0 0.0012207 /end COMPU_METHOD
/begin COMPU_METHOD F_1_p1_28 "" RAT_FUNC "%9.2" "mA" COEFFS 0 1 -1 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD F_0v00244_p0_30 "" RAT_FUNC "%9.3" "V" COEFFS 0 1 0 0 0 0.00244 /end COMPU_METHOD
/begin COMPU_METHOD F_0v0043883505_p0_31 "" RAT_FUNC "%9.3" "V" COEFFS 0 1 0 0 0 0.00438835 /end COMPU_METHOD
/begin COMPU_METHOD F_0v0625_p0_32 "" RAT_FUNC "%9.2" "eC" COEFFS 0 1 0 0 0 0.0625 /end COMPU_METHOD
/begin COMPU_METHOD F_0v0134277344_p0_33 "" RAT_FUNC "%9.2" "V" COEFFS 0 1 0 0 0 0.0134277 /end COMPU_METHOD
/begin COMPU_METHOD Id_0x00 "" RAT_FUNC "%9.2" "." COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Bool_ON_OFF "" TAB_VERB "%8.4" "." COMPU_TAB_REF Bool_ON_OFF_table /end COMPU_METHOD
/begin COMPU_VTAB Bool_ON_OFF_table "" TAB_VERB 2 0 "OFF" 1 "ON" /end COMPU_VTAB
/begin FUNCTION SWTST "" FUNCTION_VERSION "NONE_"
 /begin OUT_MEASUREMENT SWTST_au8FimDemEveStsReal[269] SWTST_au8FimDemEveStsReal[26] SWTST_au8FimDemEveStsReal[270] SWTST_au8FimDemEveStsReal[271] SWTST_au8FimDemEveStsReal[272] SWTST_au8FimDemEveStsReal[273] SWTST_au8FimDemEveStsReal[274] SWTST_au8FimDemEveStsReal[275] SWTST_au8FimDemEveStsReal[276] SWTST_au8FimDemEveStsReal[277] SWTST_au8FimDemEveStsReal[278] SWTST_au8FimDemEveStsReal[279] SWTST_au8FimDemEveStsReal[27] SWTST_au8FimDemEveStsReal[280] SWTST_au8FimDemEveStsReal[281] SWTST_au8FimDemEveStsReal[282] SWTST_au8FimDemEveStsReal[283] SWTST_au8FimDemEveStsReal[284] SWTST_au8FimDemEveStsReal[285] SWTST_au8FimDemEveStsReal[286] SWTST_au8FimDemEveStsReal[287] SWTST_au8FimDemEveStsReal[288] SWTST_au8FimDemEveStsReal[289] SWTST_au8FimDemEveStsReal[28] SWTST_au8FimDemEveStsReal[290] SWTST_au8FimDemEveStsReal[291] SWTST_au8FimDemEveStsReal[292] SWTST_au8FimDemEveStsReal[293] SWTST_au8FimDemEveStsReal[294] SWTST_au8FimDemEveStsReal[295] SWTST_au8FimDemEveStsReal[296] SWTST_au8FimDemEveStsReal[297] SWTST_au8FimDemEveStsReal[298] SWTST_au8FimDemEveStsReal[299] SWTST_au8FimDemEveStsReal[29] SWTST_au8FimDemEveStsReal[2] SWTST_au8FimDemEveStsReal[300] SWTST_au8FimDemEveStsReal[301] SWTST_au8FimDemEveStsReal[302] SWTST_au8FimDemEveStsReal[303] SWTST_au8FimDemEveStsReal[304] SWTST_au8FimDemEveStsReal[305] SWTST_au8FimDemEveStsReal[306] SWTST_au8FimDemEveStsReal[307] SWTST_au8FimDemEveStsReal[308] SWTST_au8FimDemEveStsReal[309] SWTST_au8FimDemEveStsReal[30] SWTST_au8FimDemEveStsReal[310] SWTST_au8FimDemEveStsReal[311] SWTST_au8FimDemEveStsReal[312] SWTST_au8FimDemEveStsReal[313] SWTST_au8FimDemEveStsReal[314] SWTST_au8FimDemEveStsReal[315] SWTST_au8FimDemEveStsReal[316] SWTST_au8FimDemEveStsReal[317] SWTST_au8FimDemEveStsReal[318] SWTST_au8FimDemEveStsReal[319] SWTST_au8FimDemEveStsReal[31] SWTST_au8FimDemEveStsReal[320] SWTST_au8FimDemEveStsReal[321] SWTST_au8FimDemEveStsReal[322] SWTST_au8FimDemEveStsReal[323] SWTST_au8FimDemEveStsReal[324] SWTST_au8FimDemEveStsReal[325] SWTST_au8FimDemEveStsReal[326] SWTST_au8FimDemEveStsReal[327] SWTST_au8FimDemEveStsReal[328] SWTST_au8FimDemEveStsReal[329] SWTST_au8FimDemEveStsReal[32] SWTST_au8FimDemEveStsReal[330] SWTST_au8FimDemEveStsReal[331] SWTST_au8FimDemEveStsReal[332] SWTST_au8FimDemEveStsReal[333] SWTST_au8FimDemEveStsReal[334] SWTST_au8FimDemEveStsReal[335] SWTST_au8FimDemEveStsReal[336] SWTST_au8FimDemEveStsReal[337] SWTST_au8FimDemEveStsReal[338] SWTST_au8FimDemEveStsReal[339] SWTST_au8FimDemEveStsReal[33] SWTST_au8FimDemEveStsReal[340] SWTST_au8FimDemEveStsReal[341] SWTST_au8FimDemEveStsReal[342] SWTST_au8FimDemEveStsReal[343] SWTST_au8FimDemEveStsReal[344] SWTST_au8FimDemEveStsReal[345] SWTST_au8FimDemEveStsReal[346] SWTST_au8FimDemEveStsReal[347] SWTST_au8FimDemEveStsReal[348] SWTST_au8FimDemEveStsReal[349] SWTST_au8FimDemEveStsReal[34] SWTST_au8FimDemEveStsReal[350] SWTST_au8FimDemEveStsReal[351] SWTST_au8FimDemEveStsReal[352] SWTST_au8FimDemEveStsReal[353] SWTST_au8FimDemEveStsReal[354] SWTST_au8FimDemEveStsReal[35] SWTST_au8FimDemEveStsReal[36] SWTST_au8FimDemEveStsReal[37] SWTST_au8FimDemEveStsReal[38] SWTST_au8FimDemEveStsReal[39] SWTST_au8FimDemEveStsReal[3] SWTST_au8FimDemEveStsReal[40] SWTST_au8FimDemEveStsReal[41] SWTST_au8FimDemEveStsReal[42] SWTST_au8FimDemEveStsReal[43] SWTST_au8FimDemEveStsReal[44] SWTST_au8FimDemEveStsReal[45] SWTST_au8FimDemEveStsReal[46] SWTST_au8FimDemEveStsReal[47] SWTST_au8FimDemEveStsReal[48] SWTST_au8FimDemEveStsReal[49] SWTST_au8FimDemEveStsReal[4] SWTST_au8FimDemEveStsReal[50] SWTST_au8FimDemEveStsReal[51] SWTST_au8FimDemEveStsReal[52] SWTST_au8FimDemEveStsReal[53] SWTST_au8FimDemEveStsReal[54] SWTST_au8FimDemEveStsReal[55] SWTST_au8FimDemEveStsReal[56] SWTST_au8FimDemEveStsReal[57] SWTST_au8FimDemEveStsReal[58] SWTST_au8FimDemEveStsReal[59] SWTST_au8FimDemEveStsReal[5] SWTST_au8FimDemEveStsReal[60] SWTST_au8FimDemEveStsReal[61] SWTST_au8FimDemEveStsReal[62] SWTST_au8FimDemEveStsReal[63] SWTST_au8FimDemEveStsReal[64] SWTST_au8FimDemEveStsReal[65] SWTST_au8FimDemEveStsReal[66] SWTST_au8FimDemEveStsReal[67] SWTST_au8FimDemEveStsReal[68] SWTST_au8FimDemEveStsReal[69] SWTST_au8FimDemEveStsReal[6] SWTST_au8FimDemEveStsReal[70] SWTST_au8FimDemEveStsReal[71] SWTST_au8FimDemEveStsReal[72] SWTST_au8FimDemEveStsReal[73] SWTST_au8FimDemEveStsReal[74] SWTST_au8FimDemEveStsReal[75] SWTST_au8FimDemEveStsReal[76] SWTST_au8FimDemEveStsReal[77] SWTST_au8FimDemEveStsReal[78] SWTST_au8FimDemEveStsReal[79] SWTST_au8FimDemEveStsReal[7] SWTST_au8FimDemEveStsReal[80] SWTST_au8FimDemEveStsReal[81] SWTST_au8FimDemEveStsReal[82] SWTST_au8FimDemEveStsReal[83] SWTST_au8FimDemEveStsReal[84] SWTST_au8FimDemEveStsReal[85] SWTST_au8FimDemEveStsReal[86] SWTST_au8FimDemEveStsReal[87] SWTST_au8FimDemEveStsReal[88] SWTST_au8FimDemEveStsReal[89] SWTST_au8FimDemEveStsReal[8] SWTST_au8FimDemEveStsReal[90] SWTST_au8FimDemEveStsReal[91] SWTST_au8FimDemEveStsReal[92] SWTST_au8FimDemEveStsReal[93] SWTST_au8FimDemEveStsReal[94] SWTST_au8FimDemEveStsReal[95] SWTST_au8FimDemEveStsReal[96] SWTST_au8FimDemEveStsReal[97] SWTST_au8FimDemEveStsReal[98] SWTST_au8FimDemEveStsReal[99] SWTST_au8FimDemEveStsReal[9] SWTST_au8FimFidPerm SWTST_au8FimFidPerm[0] SWTST_au8FimFidPerm[10] SWTST_au8FimFidPerm[11] SWTST_au8FimFidPerm[12] SWTST_au8FimFidPerm[13] SWTST_au8FimFidPerm[14] SWTST_au8FimFidPerm[15] SWTST_au8FimFidPerm[16] SWTST_au8FimFidPerm[17] SWTST_au8FimFidPerm[18] SWTST_au8FimFidPerm[19] SWTST_au8FimFidPerm[1] SWTST_au8FimFidPerm[2] SWTST_au8FimFidPerm[3] SWTST_au8FimFidPerm[4] SWTST_au8FimFidPerm[5] SWTST_au8FimFidPerm[6] SWTST_au8FimFidPerm[7] SWTST_au8FimFidPerm[8] SWTST_au8FimFidPerm[9] SWTST_au8Tle62X0RdDiag SWTST_au8Tle62X0RdDiag[0] SWTST_au8Tle62X0RdDiag[10] SWTST_au8Tle62X0RdDiag[11] SWTST_au8Tle62X0RdDiag[1] SWTST_au8Tle62X0RdDiag[2] SWTST_au8Tle62X0RdDiag[3] SWTST_au8Tle62X0RdDiag[4] SWTST_au8Tle62X0RdDiag[5] SWTST_au8Tle62X0RdDiag[6] SWTST_au8Tle62X0RdDiag[7] SWTST_au8Tle62X0RdDiag[8] SWTST_au8Tle62X0RdDiag[9] SWTST_avu8Tle8242OpenFltTst SWTST_avu8Tle8242OpenFltTst[0] SWTST_avu8Tle8242OpenFltTst[10] SWTST_avu8Tle8242OpenFltTst[11] SWTST_avu8Tle8242OpenFltTst[12] SWTST_avu8Tle8242OpenFltTst[13] SWTST_avu8Tle8242OpenFltTst[14] SWTST_avu8Tle8242OpenFltTst[1] SWTST_avu8Tle8242OpenFltTst[2] SWTST_avu8Tle8242OpenFltTst[3] SWTST_avu8Tle8242OpenFltTst[4] SWTST_avu8Tle8242OpenFltTst[5] SWTST_avu8Tle8242OpenFltTst[6] SWTST_avu8Tle8242OpenFltTst[7] SWTST_avu8Tle8242OpenFltTst[8] SWTST_avu8Tle8242OpenFltTst[9] SWTST_avu8Tle8242OverLoadFltTst SWTST_avu8Tle8242OverLoadFltTst[0] SWTST_avu8Tle8242OverLoadFltTst[10] SWTST_avu8Tle8242OverLoadFltTst[11] SWTST_avu8Tle8242OverLoadFltTst[12] SWTST_avu8Tle8242OverLoadFltTst[13] SWTST_avu8Tle8242OverLoadFltTst[14] SWTST_avu8Tle8242OverLoadFltTst[1] SWTST_avu8Tle8242OverLoadFltTst[2] SWTST_avu8Tle8242OverLoadFltTst[3] SWTST_avu8Tle8242OverLoadFltTst[4] SWTST_avu8Tle8242OverLoadFltTst[5] SWTST_avu8Tle8242OverLoadFltTst[6] SWTST_avu8Tle8242OverLoadFltTst[7] SWTST_avu8Tle8242OverLoadFltTst[8] SWTST_avu8Tle8242OverLoadFltTst[9] SWTST_avu8Tle8242ScFltTst SWTST_avu8Tle8242ScFltTst[0] SWTST_avu8Tle8242ScFltTst[10] SWTST_avu8Tle8242ScFltTst[11] SWTST_avu8Tle8242ScFltTst[12] SWTST_avu8Tle8242ScFltTst[13] SWTST_avu8Tle8242ScFltTst[14] SWTST_avu8Tle8242ScFltTst[1] SWTST_avu8Tle8242ScFltTst[2] SWTST_avu8Tle8242ScFltTst[3] SWTST_avu8Tle8242ScFltTst[4] SWTST_avu8Tle8242ScFltTst[5] SWTST_avu8Tle8242ScFltTst[6] SWTST_avu8Tle8242ScFltTst[7] SWTST_avu8Tle8242ScFltTst[8] SWTST_avu8Tle8242ScFltTst[9] SWTST_avu8Tle8242ScsFltTst SWTST_avu8Tle8242ScsFltTst[0] SWTST_avu8Tle8242ScsFltTst[10] SWTST_avu8Tle8242ScsFltTst[11] SWTST_avu8Tle8242ScsFltTst[12] SWTST_avu8Tle8242ScsFltTst[13] SWTST_avu8Tle8242ScsFltTst[14] SWTST_avu8Tle8242ScsFltTst[1] SWTST_avu8Tle8242ScsFltTst[2] SWTST_avu8Tle8242ScsFltTst[3] SWTST_avu8Tle8242ScsFltTst[4] SWTST_avu8Tle8242ScsFltTst[5] SWTST_avu8Tle8242ScsFltTst[6] SWTST_avu8Tle8242ScsFltTst[7] SWTST_avu8Tle8242ScsFltTst[8] SWTST_avu8Tle8242ScsFltTst[9] SWTST_avu8Tle8242UnderLoadFltTst SWTST_avu8Tle8242UnderLoadFltTst[0] SWTST_avu8Tle8242UnderLoadFltTst[10] SWTST_avu8Tle8242UnderLoadFltTst[11] SWTST_avu8Tle8242UnderLoadFltTst[12] SWTST_avu8Tle8242UnderLoadFltTst[13] SWTST_avu8Tle8242UnderLoadFltTst[14] SWTST_avu8Tle8242UnderLoadFltTst[1] SWTST_avu8Tle8242UnderLoadFltTst[2] SWTST_avu8Tle8242UnderLoadFltTst[3] SWTST_avu8Tle8242UnderLoadFltTst[4] SWTST_avu8Tle8242UnderLoadFltTst[5] SWTST_avu8Tle8242UnderLoadFltTst[6] SWTST_avu8Tle8242UnderLoadFltTst[7] SWTST_avu8Tle8242UnderLoadFltTst[8] SWTST_avu8Tle8242UnderLoadFltTst[9] SWTST_bDioRdDigitalSpare SWTST_bDioRdDiSpareDigitalInput SWTST_bDioRdHybrid SWTST_bDioRdInStb1 SWTST_bDioRdInStb1Raw SWTST_bDioRdInStb2 SWTST_bDioRdInStb2Raw SWTST_bDioRdInStb3 SWTST_bDioRdInStb3Raw SWTST_bDioRdInStb4 SWTST_bDioRdInStb4Raw SWTST_bDioRdInStb5 SWTST_bDioRdInStb5Raw SWTST_bDioRdInStb6 SWTST_bDioRdInStb6Raw SWTST_bDioRdInStb7 SWTST_bDioRdInStb7Raw SWTST_bDioRdInStb8 SWTST_bDioRdInStb8Raw SWTST_bDioRdInStg1 SWTST_bDioRdInStg10 SWTST_bDioRdInStg10Raw SWTST_bDioRdInStg11 SWTST_bDioRdInStg11Raw SWTST_bDioRdInStg12 SWTST_bDioRdInStg12Raw SWTST_bDioRdInStg13 SWTST_bDioRdInStg13Raw SWTST_bDioRdInStg14 SWTST_bDioRdInStg14Raw SWTST_bDioRdInStg15 SWTST_bDioRdInStg15Raw SWTST_bDioRdInStg16 SWTST_bDioRdInStg16Raw SWTST_bDioRdInStg17 SWTST_bDioRdInStg17Raw SWTST_bDioRdInStg18 SWTST_bDioRdInStg18Raw SWTST_bDioRdInStg19 SWTST_bDioRdInStg19Raw SWTST_bDioRdInStg1Raw SWTST_bDioRdInStg2 SWTST_bDioRdInStg2Raw SWTST_bDioRdInStg3 SWTST_bDioRdInStg3Raw SWTST_bDioRdInStg4 SWTST_bDioRdInStg4Raw SWTST_bDioRdInStg5 SWTST_bDioRdInStg5Raw SWTST_bDioRdInStg6 SWTST_bDioRdInStg6Raw SWTST_bDioRdInStg7 SWTST_bDioRdInStg7Raw SWTST_bDioRdInStg8 SWTST_bDioRdInStg8Raw SWTST_bDioRdInStg9 SWTST_bDioRdInStg9Raw SWTST_bDioRdStartupIgk SWTST_bDioRdSupplySafeState SWTST_BoolEnErrValDiagc SWTST_bSftyClrCurSafeStsFlg SWTST_bSftyClrPreSafeStsFlg SWTST_bSftyClrPreSafeStsRetVal SWTST_bSftyOutOfRngTstFlg SWTST_bSftySwRstFlg SWTST_bSwcSSAuxOnOFfCmd SWTST_bSwcSSDualArPisCmd SWTST_bSwcSSLimpHomeSafCmd SWTST_bSwcSSRetAccCmd SWTST_bSwcSSSelectCoolCmd SWTST_DEM_u16EventIdCCP SWTST_DEM_u8DisDebounce SWTST_DEM_u8EventFlagCCP SWTST_f32AccelXAxis SWTST_f32AccelYAxis SWTST_f32AccelZAxis SWTST_f32ComRdCcvs1Sa00CruiseCtrlSetSpeed SWTST_f32ComRdCcvs1Sa00WheelBasedVehicleSpeed SWTST_f32ComRdCcvs1Sa17CruiseCtrlSetSpeed SWTST_f32ComRdCcvs1Sa17WheelBasedVehicleSpeed SWTST_f32ComRdCcvs1Sa232CruiseCtrlSetSpeed SWTST_f32ComRdCcvs1Sa232WheelBasedVehicleSpeed SWTST_f32ComRdCcvs1Sa23CruiseCtrlSetSpeed SWTST_f32ComRdCcvs1Sa23WheelBasedVehicleSpeed SWTST_f32ComRdCcvs1Sa33CruiseCtrlSetSpeed SWTST_f32ComRdCcvs1Sa33WheelBasedVehicleSpeed SWTST_f32ComRdCcvs1Sa39CruiseCtrlSetSpeed SWTST_f32ComRdCcvs1Sa39WheelBasedVehicleSpeed SWTST_f32ComRdCcvs1Sa49CruiseCtrlSetSpeed SWTST_f32ComRdCcvs1Sa49WheelBasedVehicleSpeed SWTST_f32ComRdEbc1Sa00BrakePedalPos SWTST_f32ComRdEbc1Sa00EngRetarderSelection SWTST_f32ComRdEbc1Sa11BrakePedalPos SWTST_f32ComRdEbc1Sa11EngRetarderSelection SWTST_f32ComRdEbc1Sa23BrakePedalPos SWTST_f32ComRdEbc1Sa23EngRetarderSelection SWTST_f32ComRdEbc1Sa33BrakePedalPos SWTST_f32ComRdEbc1Sa33EngRetarderSelection SWTST_f32ComRdEbc1Sa49BrakePedalPos SWTST_f32ComRdEbc1Sa49EngRetarderSelection SWTST_f32ComRdEc1Sa00EngDefaultTorqueLimit SWTST_f32ComRdEc1Sa00EngExRngRqstdSpdCtrlRngUpprLimit SWTST_f32ComRdEc1Sa00EngGain SWTST_f32ComRdEc1Sa00EngMaxMomentaryOverrideTimeLimit SWTST_f32ComRdEc1Sa00EngMomentOfInertia SWTST_f32ComRdEc1Sa00EngMxMmentaryOverrideSpeedPoint7 SWTST_f32ComRdEc1Sa00EngPercentTorqueAtIdlePoint1 SWTST_f32ComRdEc1Sa00EngPercentTorqueAtPoint2 SWTST_f32ComRdEc1Sa00EngPercentTorqueAtPoint3 SWTST_f32ComRdEc1Sa00EngPercentTorqueAtPoint4 SWTST_f32ComRdEc1Sa00EngPercentTorqueAtPoint5 SWTST_f32ComRdEc1Sa00EngReferenceTorque SWTST_f32ComRdEc1Sa00EngRqstdSpeedCtrlRangeLowerLimit SWTST_f32ComRdEc1Sa00EngRqstdSpeedCtrlRangeUpperLimit SWTST_f32ComRdEc1Sa00EngRqstdTrqueCtrlRangeLowerLimit SWTST_f32ComRdEc1Sa00EngRqstdTrqueCtrlRangeUpperLimit SWTST_f32ComRdEc1Sa00EngSpeedAtHighIdlePoint6 SWTST_f32ComRdEc1Sa00EngSpeedAtIdlePoint1 SWTST_f32ComRdEc1Sa00EngSpeedAtPoint2 SWTST_f32ComRdEc1Sa00EngSpeedAtPoint3 SWTST_f32ComRdEc1Sa00EngSpeedAtPoint4 SWTST_f32ComRdEc1Sa00EngSpeedAtPoint5 SWTST_f32ComRdEec1Sa00ActlEngPrcntTorqueHighResolution SWTST_f32ComRdEec1Sa00ActualEngPercentTorque SWTST_f32ComRdEec1Sa00DriversDemandEngPercentTorque SWTST_f32ComRdEec1Sa00EngDemandPercentTorque SWTST_f32ComRdEec1Sa00EngSpeed SWTST_f32ComRdEec2Sa00AccelPedalPos1 SWTST_f32ComRdEec2Sa00AccelPedalPos2 SWTST_f32ComRdEec2Sa00ActlMaxAvailableEngPercentTorque SWTST_f32ComRdEec2Sa00EngPercentLoadAtCurrentSpeed SWTST_f32ComRdEec2Sa00EstPumpingPercentTorque SWTST_f32ComRdEec2Sa00RemoteAccelPedalPos SWTST_f32ComRdEec2Sa17AccelPedalPos1 SWTST_f32ComRdEec2Sa17AccelPedalPos2 SWTST_f32ComRdEec2Sa17ActlMaxAvailableEngPercentTorque SWTST_f32ComRdEec2Sa17EngPercentLoadAtCurrentSpeed SWTST_f32ComRdEec2Sa17EstPumpingPercentTorque SWTST_f32ComRdEec2Sa17RemoteAccelPedalPos SWTST_f32ComRdEec2Sa33AccelPedalPos1 SWTST_f32ComRdEec2Sa33AccelPedalPos2 SWTST_f32ComRdEec2Sa33ActlMaxAvailableEngPercentTorque SWTST_f32ComRdEec2Sa33EngPercentLoadAtCurrentSpeed SWTST_f32ComRdEec2Sa33EstPumpingPercentTorque SWTST_f32ComRdEec2Sa33RemoteAccelPedalPos SWTST_f32ComRdEec2Sa49AccelPedalPos1 SWTST_f32ComRdEec2Sa49AccelPedalPos2 SWTST_f32ComRdEec2Sa49ActlMaxAvailableEngPercentTorque SWTST_f32ComRdEec2Sa49EngPercentLoadAtCurrentSpeed SWTST_f32ComRdEec2Sa49EstPumpingPercentTorque SWTST_f32ComRdEec2Sa49RemoteAccelPedalPos SWTST_f32ComRdEec3Sa00AFT1ExhGasMFR SWTST_f32ComRdEec3Sa00EnginesDesiredOperatingSpeed SWTST_f32ComRdEec3Sa00EngnsDsrdOprtngSpdAsymmtryAdjstm SWTST_f32ComRdEec3Sa00EstEngPrsiticLossesPercentTorque SWTST_f32ComRdEec3Sa00NominalFrictionPercentTorque SWTST_f32ComRdErc1Sa00ActlMxAvlblRetarderPercentTorque SWTST_f32ComRdErc1Sa00ActualRetarderPercentTorque SWTST_f32ComRdErc1Sa00DrvrsDemandRetarderPercentTorque SWTST_f32ComRdErc1Sa00IntendedRetarderPercentTorque SWTST_f32ComRdErc1Sa00RetarderSelectionNonengine SWTST_f32ComRdErc1Sa15ActlMxAvlblRetarderPercentTorque SWTST_f32ComRdErc1Sa15ActualRetarderPercentTorque SWTST_f32ComRdErc1Sa15DrvrsDemandRetarderPercentTorque SWTST_f32ComRdErc1Sa15IntendedRetarderPercentTorque SWTST_f32ComRdErc1Sa15RetarderSelectionNonengine SWTST_f32ComRdErc1Sa23ActlMxAvlblRetarderPercentTorque SWTST_f32ComRdErc1Sa23ActualRetarderPercentTorque SWTST_f32ComRdErc1Sa23DrvrsDemandRetarderPercentTorque SWTST_f32ComRdErc1Sa23IntendedRetarderPercentTorque SWTST_f32ComRdErc1Sa23RetarderSelectionNonengine SWTST_f32ComRdErc1Sa33ActlMxAvlblRetarderPercentTorque SWTST_f32ComRdErc1Sa33ActualRetarderPercentTorque SWTST_f32ComRdErc1Sa33DrvrsDemandRetarderPercentTorque SWTST_f32ComRdErc1Sa33IntendedRetarderPercentTorque SWTST_f32ComRdErc1Sa33RetarderSelectionNonengine SWTST_f32ComRdErc1Sa41ActlMxAvlblRetarderPercentTorque SWTST_f32ComRdErc1Sa41ActualRetarderPercentTorque SWTST_f32ComRdErc1Sa41DrvrsDemandRetarderPercentTorque SWTST_f32ComRdErc1Sa41IntendedRetarderPercentTorque SWTST_f32ComRdErc1Sa41RetarderSelectionNonengine SWTST_f32ComRdErc1Sa49ActlMxAvlblRetarderPercentTorque SWTST_f32ComRdErc1Sa49ActualRetarderPercentTorque SWTST_f32ComRdErc1Sa49DrvrsDemandRetarderPercentTorque SWTST_f32ComRdErc1Sa49IntendedRetarderPercentTorque SWTST_f32ComRdErc1Sa49RetarderSelectionNonengine SWTST_f32ComRdEt1Sa00EngCoolantTemp SWTST_f32ComRdEt1Sa00EngFuelTemp1 SWTST_f32ComRdEt1Sa00EngIntercoolerTemp SWTST_f32ComRdEt1Sa00EngIntercoolerThermostatOpening SWTST_f32ComRdEt1Sa00EngOilTemp1 SWTST_f32ComRdEt1Sa00EngTurboOilTemp SWTST_f32ComRdLfeSa00EngAverageFuelEconomy SWTST_f32ComRdLfeSa00EngFuelRate SWTST_f32ComRdLfeSa00EngInstantaneousFuelEconomy SWTST_f32ComRdLfeSa00EngThrottleValve1Pos SWTST_f32ComRdLfeSa00EngThrottleValve2Pos SWTST_f32ComRdRcSa15MaxRetarderSpeedPoint2 SWTST_f32ComRdRcSa15PercentTorqueAtIdlePoint1 SWTST_f32ComRdRcSa15PercentTorqueAtMaxSpeedPoint2 SWTST_f32ComRdRcSa15PercentTorqueAtPeakTorquePoint5 SWTST_f32ComRdRcSa15PercentTorqueAtPoint3 SWTST_f32ComRdRcSa15PercentTorqueAtPoint4 SWTST_f32ComRdRcSa15ReferenceRetarderTorque SWTST_f32ComRdRcSa15RetarderSpeedAtIdlePoint1 SWTST_f32ComRdRcSa15RetarderSpeedAtPeakTorquePoint5 SWTST_f32ComRdRcSa15RetarderSpeedAtPoint3 SWTST_f32ComRdRcSa15RetarderSpeedAtPoint4 SWTST_f32ComRdRcSa41MaxRetarderSpeedPoint2 SWTST_f32ComRdRcSa41PercentTorqueAtIdlePoint1 SWTST_f32ComRdRcSa41PercentTorqueAtMaxSpeedPoint2 SWTST_f32ComRdRcSa41PercentTorqueAtPeakTorquePoint5 SWTST_f32ComRdRcSa41PercentTorqueAtPoint3 SWTST_f32ComRdRcSa41PercentTorqueAtPoint4 SWTST_f32ComRdRcSa41ReferenceRetarderTorque SWTST_f32ComRdRcSa41RetarderSpeedAtIdlePoint1 SWTST_f32ComRdRcSa41RetarderSpeedAtPeakTorquePoint5 SWTST_f32ComRdRcSa41RetarderSpeedAtPoint3 SWTST_f32ComRdRcSa41RetarderSpeedAtPoint4 SWTST_f32ComRdRxBMSCelInforSa243RxBatMaxCellTemp SWTST_f32ComRdRxBMSCelInforSa243RxBatMaxCellVoltg SWTST_f32ComRdRxBMSCelInforSa243RxBatMinCellTemp SWTST_f32ComRdRxBMSCelInforSa243RxBatMinCellVoltg SWTST_f32ComRdRxBMSCelInforSa243RxBatSystCellVoltgDiff SWTST_f32ComRdRxBMSFailSa243RxBMSCANVersion SWTST_f32ComRdRxBMSMainParaSa243RxBatSOC SWTST_f32ComRdRxBMSMainParaSa243RxBatTotalCurrent SWTST_f32ComRdRxBMSMainParaSa243RxBatTotalVoltage SWTST_f32ComRdRxBrkPumpCtrlSa155Da255RxBrkPumpCtrlBusVolt SWTST_f32ComRdRxBrkPumpCtrlSa155Da255RxBrkPumpCtrlSpdMot SWTST_f32ComRdRxBrkPumpCtrlSa155Da255RxBrkPumpCtrlTemp SWTST_f32ComRdRxDBStaVehSa23RxDBBacBraPres SWTST_f32ComRdRxDBStaVehSa23RxDBBatVoltage SWTST_f32ComRdRxDBStaVehSa23RxDBFroBraPres SWTST_f32ComRdRxDCDCCtrl1Sa243RxDCDCCtrl1OutputCurrent SWTST_f32ComRdRxDCDCCtrl1Sa243RxDCDCCtrl1OutputVolt SWTST_f32ComRdRxDCDCCtrl1Sa243RxDCDCCtrl1Temp SWTST_f32ComRdRxMCUStatus1Sa08RxMCUMotACCurrent SWTST_f32ComRdRxMCUStatus1Sa08RxMCUMotSpd SWTST_f32ComRdRxMCUStatus1Sa08RxMCUMotTrq SWTST_f32ComRdRxMCUStatus2Sa08RxMCUMotControllerTemp SWTST_f32ComRdRxMCUStatus2Sa08RxMCUMotMinTrqLmt SWTST_f32ComRdRxMCUStatus2Sa08RxMCUMotTemp SWTST_f32ComRdRxMCUStatus3Sa08RxMCUDCCurr SWTST_f32ComRdRxMCUStatus3Sa08RxMCUDCVolt SWTST_f32ComRdRxSteerPumpCtrlSa149Da255RxSteerPumpCtrlBusVolt SWTST_f32ComRdRxSteerPumpCtrlSa149Da255RxSteerPumpCtrlSpdMot SWTST_f32ComRdRxSteerPumpCtrlSa149Da255RxSteerPumpCtrlTemp SWTST_f32ComRdTc1Sa05Da255RequestedPercentClutchSlip SWTST_f32ComRdTc1Sa05Da255TransRequestedGear SWTST_f32ComRdTc1Sa05RequestedPercentClutchSlip SWTST_f32ComRdTc1Sa05TransRequestedGear SWTST_f32ComRdTc1Sa06Da255RequestedPercentClutchSlip SWTST_f32ComRdTc1Sa06Da255TransRequestedGear SWTST_f32ComRdTc1Sa06RequestedPercentClutchSlip SWTST_f32ComRdTc1Sa06TransRequestedGear SWTST_f32ComRdTc1Sa23Da255RequestedPercentClutchSlip SWTST_f32ComRdTc1Sa23Da255TransRequestedGear SWTST_f32ComRdTc1Sa23RequestedPercentClutchSlip SWTST_f32ComRdTc1Sa23TransRequestedGear SWTST_f32ComRdTc1Sa33Da255RequestedPercentClutchSlip SWTST_f32ComRdTc1Sa33Da255TransRequestedGear SWTST_f32ComRdTc1Sa33RequestedPercentClutchSlip SWTST_f32ComRdTc1Sa33TransRequestedGear SWTST_f32ComRdTc1Sa42Da255RequestedPercentClutchSlip SWTST_f32ComRdTc1Sa42Da255TransRequestedGear SWTST_f32ComRdTc1Sa42RequestedPercentClutchSlip SWTST_f32ComRdTc1Sa42TransRequestedGear SWTST_f32ComRdTc1Sa49Da255RequestedPercentClutchSlip SWTST_f32ComRdTc1Sa49Da255TransRequestedGear SWTST_f32ComRdTc1Sa49RequestedPercentClutchSlip SWTST_f32ComRdTc1Sa49TransRequestedGear SWTST_f32ComRdTsc1Sa00EngRequestedSpeedSpeedLimit SWTST_f32ComRdTsc1Sa00EngRequestedTorqueHighResolution SWTST_f32ComRdTsc1Sa00EngRequestedTorqueTorqueLimit SWTST_f32ComRdTsc1Sa11EngRequestedSpeedSpeedLimit SWTST_f32ComRdTsc1Sa11EngRequestedTorqueHighResolution SWTST_f32ComRdTsc1Sa11EngRequestedTorqueTorqueLimit SWTST_f32ComRdTsc1Sa17EngRequestedSpeedSpeedLimit SWTST_f32ComRdTsc1Sa17EngRequestedTorqueHighResolution SWTST_f32ComRdTsc1Sa17EngRequestedTorqueTorqueLimit SWTST_f32ComRdTsc1Sa33EngRequestedSpeedSpeedLimit SWTST_f32ComRdTsc1Sa33EngRequestedTorqueHighResolution SWTST_f32ComRdTsc1Sa33EngRequestedTorqueTorqueLimit SWTST_f32ComRdTsc1Sa39EngRequestedSpeedSpeedLimit SWTST_f32ComRdTsc1Sa39EngRequestedTorqueHighResolution SWTST_f32ComRdTsc1Sa39EngRequestedTorqueTorqueLimit SWTST_f32ComRdTsc1Sa42EngRequestedSpeedSpeedLimit SWTST_f32ComRdTsc1Sa42EngRequestedTorqueHighResolution SWTST_f32ComRdTsc1Sa42EngRequestedTorqueTorqueLimit SWTST_f32Swc5VSply1 SWTST_f32Swc5VSply2 SWTST_f32Swc9VSply1 SWTST_f32TLE8242_LINEAR_VALVE_1_1_AvgCrnt SWTST_f32TLE8242_LINEAR_VALVE_1_1_DitherAmplFb SWTST_f32TLE8242_LINEAR_VALVE_1_1_DitherFrqFb SWTST_f32TLE8242_LINEAR_VALVE_1_1_MaxCrnt SWTST_f32TLE8242_LINEAR_VALVE_1_1_MinCrnt SWTST_f32TLE8242_LINEAR_VALVE_1_1_PwmDutyFb SWTST_f32TLE8242_LINEAR_VALVE_1_2_AvgCrnt SWTST_f32TLE8242_LINEAR_VALVE_1_2_DitherAmplFb SWTST_f32TLE8242_LINEAR_VALVE_1_2_DitherFrqFb SWTST_f32TLE8242_LINEAR_VALVE_1_2_MaxCrnt SWTST_f32TLE8242_LINEAR_VALVE_1_2_MinCrnt SWTST_f32TLE8242_LINEAR_VALVE_1_2_PwmDutyFb SWTST_f32TLE8242_LINEAR_VALVE_2_3_AvgCrnt SWTST_f32TLE8242_LINEAR_VALVE_2_3_DitherAmplFb SWTST_f32TLE8242_LINEAR_VALVE_2_3_DitherFrqFb SWTST_f32TLE8242_LINEAR_VALVE_2_3_MaxCrnt SWTST_f32TLE8242_LINEAR_VALVE_2_3_MinCrnt SWTST_f32TLE8242_LINEAR_VALVE_2_3_PwmDutyFb SWTST_f32TLE8242_LINEAR_VALVE_2_4_AvgCrnt SWTST_f32TLE8242_LINEAR_VALVE_2_4_DitherAmplFb SWTST_f32TLE8242_LINEAR_VALVE_2_4_DitherFrqFb SWTST_f32TLE8242_LINEAR_VALVE_2_4_MaxCrnt SWTST_f32TLE8242_LINEAR_VALVE_2_4_MinCrnt SWTST_f32TLE8242_LINEAR_VALVE_2_4_PwmDutyFb SWTST_f32TLE8242_LINEAR_VALVE_2_5_AvgCrnt SWTST_f32TLE8242_LINEAR_VALVE_2_5_DitherAmplFb SWTST_f32TLE8242_LINEAR_VALVE_2_5_DitherFrqFb SWTST_f32TLE8242_LINEAR_VALVE_2_5_MaxCrnt SWTST_f32TLE8242_LINEAR_VALVE_2_5_MinCrnt SWTST_f32TLE8242_LINEAR_VALVE_2_5_PwmDutyFb SWTST_f32TLE8242_LINEAR_VALVE_3_6_AvgCrnt SWTST_f32TLE8242_LINEAR_VALVE_3_6_DitherAmplFb SWTST_f32TLE8242_LINEAR_VALVE_3_6_DitherFrqFb SWTST_f32TLE8242_LINEAR_VALVE_3_6_MaxCrnt SWTST_f32TLE8242_LINEAR_VALVE_3_6_MinCrnt SWTST_f32TLE8242_LINEAR_VALVE_3_6_PwmDutyFb SWTST_f32TLE8242_LINEAR_VALVE_3_7_AvgCrnt SWTST_f32TLE8242_LINEAR_VALVE_3_7_DitherAmplFb SWTST_f32TLE8242_LINEAR_VALVE_3_7_DitherFrqFb SWTST_f32TLE8242_LINEAR_VALVE_3_7_MaxCrnt SWTST_f32TLE8242_LINEAR_VALVE_3_7_MinCrnt SWTST_f32TLE8242_LINEAR_VALVE_3_7_PwmDutyFb SWTST_f32TLE8242_LINEAR_VALVE_3_8_AvgCrnt SWTST_f32TLE8242_LINEAR_VALVE_3_8_DitherAmplFb SWTST_f32TLE8242_LINEAR_VALVE_3_8_DitherFrqFb SWTST_f32TLE8242_LINEAR_VALVE_3_8_MaxCrnt SWTST_f32TLE8242_LINEAR_VALVE_3_8_MinCrnt SWTST_f32TLE8242_LINEAR_VALVE_3_8_PwmDutyFb SWTST_f32TLE8242_LINEAR_VALVE_4_10_AvgCrnt SWTST_f32TLE8242_LINEAR_VALVE_4_10_DitherAmplFb SWTST_f32TLE8242_LINEAR_VALVE_4_10_DitherFrqFb SWTST_f32TLE8242_LINEAR_VALVE_4_10_MaxCrnt SWTST_f32TLE8242_LINEAR_VALVE_4_10_MinCrnt SWTST_f32TLE8242_LINEAR_VALVE_4_10_PwmDutyFb SWTST_f32TLE8242_LINEAR_VALVE_4_9_AvgCrnt SWTST_f32TLE8242_LINEAR_VALVE_4_9_DitherAmplFb SWTST_f32TLE8242_LINEAR_VALVE_4_9_DitherFrqFb SWTST_f32TLE8242_LINEAR_VALVE_4_9_MaxCrnt SWTST_f32TLE8242_LINEAR_VALVE_4_9_MinCrnt SWTST_f32TLE8242_LINEAR_VALVE_4_9_PwmDutyFb SWTST_f32TLE8242_PWM_VALVE_1_1_AvgCrnt SWTST_f32TLE8242_PWM_VALVE_1_1_DitherAmplFb SWTST_f32TLE8242_PWM_VALVE_1_1_DitherFrqFb SWTST_f32TLE8242_PWM_VALVE_1_1_MaxCrnt SWTST_f32TLE8242_PWM_VALVE_1_1_MinCrnt SWTST_f32TLE8242_PWM_VALVE_1_1_PwmDutyFb SWTST_f32TLE8242_PWM_VALVE_1_2_AvgCrnt SWTST_f32TLE8242_PWM_VALVE_1_2_DitherAmplFb SWTST_f32TLE8242_PWM_VALVE_1_2_DitherFrqFb SWTST_f32TLE8242_PWM_VALVE_1_2_MaxCrnt SWTST_f32TLE8242_PWM_VALVE_1_2_MinCrnt SWTST_f32TLE8242_PWM_VALVE_1_2_PwmDutyFb SWTST_f32TLE8242_PWM_VALVE_1_3_AvgCrnt SWTST_f32TLE8242_PWM_VALVE_1_3_DitherAmplFb SWTST_f32TLE8242_PWM_VALVE_1_3_DitherFrqFb SWTST_f32TLE8242_PWM_VALVE_1_3_MaxCrnt SWTST_f32TLE8242_PWM_VALVE_1_3_MinCrnt SWTST_f32TLE8242_PWM_VALVE_1_3_PwmDutyFb SWTST_f32TLE8242_PWM_VALVE_4_4_AvgCrnt SWTST_f32TLE8242_PWM_VALVE_4_4_DitherAmplFb SWTST_f32TLE8242_PWM_VALVE_4_4_DitherFrqFb SWTST_f32TLE8242_PWM_VALVE_4_4_MaxCrnt SWTST_f32TLE8242_PWM_VALVE_4_4_MinCrnt SWTST_f32TLE8242_PWM_VALVE_4_4_PwmDutyFb SWTST_f32TLE8242_PWM_VALVE_4_5_AvgCrnt SWTST_f32TLE8242_PWM_VALVE_4_5_DitherAmplFb SWTST_f32TLE8242_PWM_VALVE_4_5_DitherFrqFb SWTST_f32TLE8242_PWM_VALVE_4_5_MaxCrnt SWTST_f32TLE8242_PWM_VALVE_4_5_MinCrnt SWTST_f32TLE8242_PWM_VALVE_4_5_PwmDutyFb SWTST_f32Tle8242ReadPwmFrqLnrVlv1_1 SWTST_f32Tle8242ReadPwmFrqLnrVlv1_2 SWTST_f32Tle8242ReadPwmFrqLnrVlv2_3 SWTST_f32Tle8242ReadPwmFrqLnrVlv2_4 SWTST_f32Tle8242ReadPwmFrqLnrVlv2_5 SWTST_f32Tle8242ReadPwmFrqLnrVlv3_6 SWTST_f32Tle8242ReadPwmFrqLnrVlv3_7 SWTST_f32Tle8242ReadPwmFrqLnrVlv3_8 SWTST_f32Tle8242ReadPwmFrqLnrVlv4_10 SWTST_f32Tle8242ReadPwmFrqLnrVlv4_9 SWTST_f32Tle8242ReadPwmFrqPwmVlv1_1 SWTST_f32Tle8242ReadPwmFrqPwmVlv1_2 SWTST_f32Tle8242ReadPwmFrqPwmVlv1_3 SWTST_f32Tle8242ReadPwmFrqPwmVlv4_4 SWTST_f32Tle8242ReadPwmFrqPwmVlv4_5 SWTST_f32Tle8242WrPwmFrqLnrVlv1_1 SWTST_f32Tle8242WrPwmFrqLnrVlv1_2 SWTST_f32Tle8242WrPwmFrqLnrVlv2_3 SWTST_f32Tle8242WrPwmFrqLnrVlv2_4 SWTST_f32Tle8242WrPwmFrqLnrVlv2_5 SWTST_f32Tle8242WrPwmFrqLnrVlv3_6 SWTST_f32Tle8242WrPwmFrqLnrVlv3_7 SWTST_f32Tle8242WrPwmFrqLnrVlv3_8 SWTST_f32Tle8242WrPwmFrqLnrVlv4_10 SWTST_f32Tle8242WrPwmFrqLnrVlv4_9 SWTST_f32Tle8242WrPwmFrqPwmVlv1_1 SWTST_f32Tle8242WrPwmFrqPwmVlv1_2 SWTST_f32Tle8242WrPwmFrqPwmVlv1_3 SWTST_f32Tle8242WrPwmFrqPwmVlv4_4 SWTST_f32Tle8242WrPwmFrqPwmVlv4_5 SWTST_kbPwdTstEnaC SWTST_ku8ComWrCiSa03CptIdnLen SWTST_ku8ComWrSoftLen SWTST_s16RdAnDiagHsSw12 SWTST_s16RdAnDiagHsSw34 SWTST_s16RdAnDiagSolSw1 SWTST_s16RdAnDiagSolSw2 SWTST_s16RdAnDiagSolSw3 SWTST_s16RdAnDiagSolSw4 SWTST_s16RdAnEngSpdHall SWTST_s16RdAnEngSpdVr SWTST_s16RdAnInAnlgTemp1 SWTST_s16RdAnInAnlgTemp2 SWTST_s16RdAnInAnlgTemp3 SWTST_s16RdAnInAnlgVolt1 SWTST_s16RdAnInAnlgVolt2 SWTST_s16RdAnInAnlgVolt3 SWTST_s16RdAnInAnlgVolt4 SWTST_s16RdAnInAnlgVolt5 SWTST_s16RdAnInAnlgVolt6 SWTST_s16RdAnInputSpdHall SWTST_s16RdAnIptSpdVr SWTST_s16RdAnOutputSpdHall SWTST_s16RdAnOutSpdVr SWTST_s16RdAnP5vSnsSup1 SWTST_s16RdAnP5vSnsSup2 SWTST_s16RdAnP9vSensSup21 SWTST_s16RdAnP9vSensSup22 SWTST_s16RdAnP9vSnsSup1 SWTST_s16RdAnPwmIn1 SWTST_s16RdAnPwmIn2 SWTST_s16RdAnTmpPcb SWTST_s16RdAnVbatKL30SwSup SWTST_s16RdAnVbatPSwSup SWTST_s16RdAnVcc5vSup SWTST_s16RdP5vSnsSup1 SWTST_s16RdP5vSnsSup2 SWTST_s16RdP9vSensSup21 SWTST_s16RdP9vSensSup22 SWTST_s16RdP9vSnsSup1 SWTST_s16RdPhysTmpMicro SWTST_s16RdPhysTmpPcb SWTST_s16RdVbatKL30SwSup SWTST_s16RdVbatPSwSup SWTST_s16RdVcc5vSup SWTST_u16ComRdRxMCUStatus2Sa08RxMCUMotMaxTrqLmt SWTST_u16Tle8242ReadKiLnrVlv1_1 SWTST_u16Tle8242ReadKiLnrVlv1_2 SWTST_u16Tle8242ReadKiLnrVlv2_3 SWTST_u16Tle8242ReadKiLnrVlv2_4 SWTST_u16Tle8242ReadKiLnrVlv2_5 SWTST_u16Tle8242ReadKiLnrVlv3_6 SWTST_u16Tle8242ReadKiLnrVlv3_7 SWTST_u16Tle8242ReadKiLnrVlv3_8 SWTST_u16Tle8242ReadKiLnrVlv4_10 SWTST_u16Tle8242ReadKiLnrVlv4_9 SWTST_u16Tle8242ReadKiPwmVlv1_1 SWTST_u16Tle8242ReadKiPwmVlv1_2 SWTST_u16Tle8242ReadKiPwmVlv1_3 SWTST_u16Tle8242ReadKiPwmVlv4_4 SWTST_u16Tle8242ReadKiPwmVlv4_5 SWTST_u16Tle8242ReadKpLnrVlv1_1 SWTST_u16Tle8242ReadKpLnrVlv1_2 SWTST_u16Tle8242ReadKpLnrVlv2_3 SWTST_u16Tle8242ReadKpLnrVlv2_4 SWTST_u16Tle8242ReadKpLnrVlv2_5 SWTST_u16Tle8242ReadKpLnrVlv3_6 SWTST_u16Tle8242ReadKpLnrVlv3_7 SWTST_u16Tle8242ReadKpLnrVlv3_8 SWTST_u16Tle8242ReadKpLnrVlv4_10 SWTST_u16Tle8242ReadKpLnrVlv4_9 SWTST_u16Tle8242ReadKpPwmVlv1_1 SWTST_u16Tle8242ReadKpPwmVlv1_2 SWTST_u16Tle8242ReadKpPwmVlv1_3 SWTST_u16Tle8242ReadKpPwmVlv4_4 SWTST_u16Tle8242ReadKpPwmVlv4_5 SWTST_u16Tle8242WrKiLnrVlv1_1 SWTST_u16Tle8242WrKiLnrVlv1_2 SWTST_u16Tle8242WrKiLnrVlv2_3 SWTST_u16Tle8242WrKiLnrVlv2_4 SWTST_u16Tle8242WrKiLnrVlv2_5 SWTST_u16Tle8242WrKiLnrVlv3_6 SWTST_u16Tle8242WrKiLnrVlv3_7 SWTST_u16Tle8242WrKiLnrVlv3_8 SWTST_u16Tle8242WrKiLnrVlv4_10 SWTST_u16Tle8242WrKiLnrVlv4_9 SWTST_u16Tle8242WrKiPwmVlv1_1 SWTST_u16Tle8242WrKiPwmVlv1_2 SWTST_u16Tle8242WrKiPwmVlv1_3 SWTST_u16Tle8242WrKiPwmVlv4_4 SWTST_u16Tle8242WrKiPwmVlv4_5 SWTST_u16Tle8242WrKpLnrVlv1_1 SWTST_u16Tle8242WrKpLnrVlv1_2 SWTST_u16Tle8242WrKpLnrVlv2_3 SWTST_u16Tle8242WrKpLnrVlv2_4 SWTST_u16Tle8242WrKpLnrVlv2_5 SWTST_u16Tle8242WrKpLnrVlv3_6 SWTST_u16Tle8242WrKpLnrVlv3_7 SWTST_u16Tle8242WrKpLnrVlv3_8 SWTST_u16Tle8242WrKpLnrVlv4_10 SWTST_u16Tle8242WrKpLnrVlv4_9 SWTST_u16Tle8242WrKpPwmVlv1_1 SWTST_u16Tle8242WrKpPwmVlv1_2 SWTST_u16Tle8242WrKpPwmVlv1_3 SWTST_u16Tle8242WrKpPwmVlv4_4 SWTST_u16Tle8242WrKpPwmVlv4_5 SWTST_u32AdcTstErrInfo SWTST_u32CalibTst0 SWTST_u32CalibTst0[0] SWTST_u32CalibTst0[10] SWTST_u32CalibTst0[11] SWTST_u32CalibTst0[12] SWTST_u32CalibTst0[13] SWTST_u32CalibTst0[14] SWTST_u32CalibTst0[15] SWTST_u32CalibTst0[16] SWTST_u32CalibTst0[17] SWTST_u32CalibTst0[18] SWTST_u32CalibTst0[19] SWTST_u32CalibTst0[1] SWTST_u32CalibTst0[20] SWTST_u32CalibTst0[21] SWTST_u32CalibTst0[22] SWTST_u32CalibTst0[23] SWTST_u32CalibTst0[24] SWTST_u32CalibTst0[25] SWTST_u32CalibTst0[26] SWTST_u32CalibTst0[27] SWTST_u32CalibTst0[28] SWTST_u32CalibTst0[29] SWTST_u32CalibTst0[2] SWTST_u32CalibTst0[30] SWTST_u32CalibTst0[31] SWTST_u32CalibTst0[32] SWTST_u32CalibTst0[33] SWTST_u32CalibTst0[34] SWTST_u32CalibTst0[35] SWTST_u32CalibTst0[36] SWTST_u32CalibTst0[37] SWTST_u32CalibTst0[38] SWTST_u32CalibTst0[39] SWTST_u32CalibTst0[3] SWTST_u32CalibTst0[40] SWTST_u32CalibTst0[41] SWTST_u32CalibTst0[42] SWTST_u32CalibTst0[43] SWTST_u32CalibTst0[44] SWTST_u32CalibTst0[45] SWTST_u32CalibTst0[46] SWTST_u32CalibTst0[47] SWTST_u32CalibTst0[48] SWTST_u32CalibTst0[49] SWTST_u32CalibTst0[4] SWTST_u32CalibTst0[50] SWTST_u32CalibTst0[51] SWTST_u32CalibTst0[52] SWTST_u32CalibTst0[53] SWTST_u32CalibTst0[54] SWTST_u32CalibTst0[55] SWTST_u32CalibTst0[56] SWTST_u32CalibTst0[57] SWTST_u32CalibTst0[58] SWTST_u32CalibTst0[59] SWTST_u32CalibTst0[5] SWTST_u32CalibTst0[60] SWTST_u32CalibTst0[61] SWTST_u32CalibTst0[62] SWTST_u32CalibTst0[63] SWTST_u32CalibTst0[64] SWTST_u32CalibTst0[65] SWTST_u32CalibTst0[66] SWTST_u32CalibTst0[67] SWTST_u32CalibTst0[68] SWTST_u32CalibTst0[69] SWTST_u32CalibTst0[6] SWTST_u32CalibTst0[70] SWTST_u32CalibTst0[71] SWTST_u32CalibTst0[72] SWTST_u32CalibTst0[73] SWTST_u32CalibTst0[74] SWTST_u32CalibTst0[75] SWTST_u32CalibTst0[76] SWTST_u32CalibTst0[77] SWTST_u32CalibTst0[78] SWTST_u32CalibTst0[79] SWTST_u32CalibTst0[7] SWTST_u32CalibTst0[80] SWTST_u32CalibTst0[81] SWTST_u32CalibTst0[82] SWTST_u32CalibTst0[83] SWTST_u32CalibTst0[84] SWTST_u32CalibTst0[85] SWTST_u32CalibTst0[86] SWTST_u32CalibTst0[87] SWTST_u32CalibTst0[88] SWTST_u32CalibTst0[89] SWTST_u32CalibTst0[8] SWTST_u32CalibTst0[90] SWTST_u32CalibTst0[91] SWTST_u32CalibTst0[92] SWTST_u32CalibTst0[93] SWTST_u32CalibTst0[94] SWTST_u32CalibTst0[95] SWTST_u32CalibTst0[96] SWTST_u32CalibTst0[97] SWTST_u32CalibTst0[98] SWTST_u32CalibTst0[99] SWTST_u32CalibTst0[9] SWTST_u32CalibTst1 SWTST_u32CalibTst10 SWTST_u32CalibTst10[0] SWTST_u32CalibTst10[10] SWTST_u32CalibTst10[11] SWTST_u32CalibTst10[12] SWTST_u32CalibTst10[13] SWTST_u32CalibTst10[14] SWTST_u32CalibTst10[15] SWTST_u32CalibTst10[16] SWTST_u32CalibTst10[17] SWTST_u32CalibTst10[18] SWTST_u32CalibTst10[19] SWTST_u32CalibTst10[1] SWTST_u32CalibTst10[20] SWTST_u32CalibTst10[21] SWTST_u32CalibTst10[22] SWTST_u32CalibTst10[23] SWTST_u32CalibTst10[24] SWTST_u32CalibTst10[25] SWTST_u32CalibTst10[26] SWTST_u32CalibTst10[27] SWTST_u32CalibTst10[28] SWTST_u32CalibTst10[29] SWTST_u32CalibTst10[2] SWTST_u32CalibTst10[30] SWTST_u32CalibTst10[31] SWTST_u32CalibTst10[32] SWTST_u32CalibTst10[33] SWTST_u32CalibTst10[34] SWTST_u32CalibTst10[35] SWTST_u32CalibTst10[36] SWTST_u32CalibTst10[37] SWTST_u32CalibTst10[38] SWTST_u32CalibTst10[39] SWTST_u32CalibTst10[3] SWTST_u32CalibTst10[40] SWTST_u32CalibTst10[41] SWTST_u32CalibTst10[42] SWTST_u32CalibTst10[43] SWTST_u32CalibTst10[44] SWTST_u32CalibTst10[45] SWTST_u32CalibTst10[46] SWTST_u32CalibTst10[47] SWTST_u32CalibTst10[48] SWTST_u32CalibTst10[49] SWTST_u32CalibTst10[4] SWTST_u32CalibTst10[50] SWTST_u32CalibTst10[51] SWTST_u32CalibTst10[52] SWTST_u32CalibTst10[53] SWTST_u32CalibTst10[54] SWTST_u32CalibTst10[55] SWTST_u32CalibTst10[56] SWTST_u32CalibTst10[57] SWTST_u32CalibTst10[58] SWTST_u32CalibTst10[59] SWTST_u32CalibTst10[5] SWTST_u32CalibTst10[60] SWTST_u32CalibTst10[61] SWTST_u32CalibTst10[62] SWTST_u32CalibTst10[63] SWTST_u32CalibTst10[64] SWTST_u32CalibTst10[65] SWTST_u32CalibTst10[66] SWTST_u32CalibTst10[67] SWTST_u32CalibTst10[68] SWTST_u32CalibTst10[69] SWTST_u32CalibTst10[6] SWTST_u32CalibTst10[70] SWTST_u32CalibTst10[71] SWTST_u32CalibTst10[72] SWTST_u32CalibTst10[73] /end OUT_MEASUREMENT
/end FUNCTION
/end MODULE
/end PROJECT
