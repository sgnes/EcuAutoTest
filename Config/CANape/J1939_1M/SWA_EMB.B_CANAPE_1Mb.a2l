ASAP2_VERSION 1 70
/begin PROJECT TEST_PROJECT "TEST_PROJECT"
/begin HEADER "TEST_PROJECT" PROJECT_NO D0 VERSION "3095.02" /end HEADER
/begin MODULE TEST_PROJECT "TestSupplier"
/begin MOD_COMMON "" DEPOSIT ABSOLUTE BYTE_ORDER MSB_LAST ALIGNMENT_BYTE 1 ALIGNMENT_WORD 2 ALIGNMENT_LONG 4 ALIGNMENT_INT64 1 ALIGNMENT_FLOAT32_IEEE 4 ALIGNMENT_FLOAT64_IEEE 8 /end MOD_COMMON
/begin RECORD_LAYOUT DATA_RECORD_UBYTE FNC_VALUES 1 UBYTE ROW_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT DATA_RECORD_UWORD FNC_VALUES 1 UWORD ROW_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT DATA_RECORD_ULONG FNC_VALUES 1 ULONG ROW_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT DATA_RECORD_FLOAT32_IEEE FNC_VALUES 1 FLOAT32_IEEE ROW_DIR DIRECT /end RECORD_LAYOUT
/begin CHARACTERISTIC SWTST_aku16Duty "SWTST_aku16Duty" MAP 0x800280CC DATA_RECORD_UWORD 399.9938965 F_0v0061035156_p0_26 0 399.9938965
 /begin AXIS_DESCR FIX_AXIS NO_INPUT_QUANTITY Id_0x00 5 0 4 MAX_GRAD 100.0 FIX_AXIS_PAR_DIST 0 1 5 /end AXIS_DESCR
 /begin AXIS_DESCR FIX_AXIS NO_INPUT_QUANTITY Id_0x00 4 0 3 MAX_GRAD 100.0 FIX_AXIS_PAR_DIST 0 1 4 /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_aku32Prd "SWTST_aku32Prd" CURVE 0x800284D4 DATA_RECORD_ULONG 21474836.48 F_0v01_p0_27 0 21474836.48
 /begin AXIS_DESCR FIX_AXIS NO_INPUT_QUANTITY Id_0x00 4 0 3 MAX_GRAD 100.0 FIX_AXIS_PAR_DIST 0 1 4 /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_1_1_CrntTar "value" VALUE 0x800286C4 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_28 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_1_1_DitherAmp "value" VALUE 0x800286C0 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_28 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_1_1_DitherFrq "value" VALUE 0x800286BC DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_29 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_1_1_PwmDuty "value" VALUE 0x800286B8 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_1_2_CrntTar "value" VALUE 0x800286B4 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_28 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_1_2_DitherAmp "value" VALUE 0x800286B0 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_28 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_1_2_DitherFrq "value" VALUE 0x800286AC DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_29 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_1_2_PwmDuty "value" VALUE 0x800286A8 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_2_3_CrntTar "value" VALUE 0x800286A4 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_28 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_2_3_DitherAmp "value" VALUE 0x800286A0 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_28 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_2_3_DitherFrq "value" VALUE 0x8002869C DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_29 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_2_3_PwmDuty "value" VALUE 0x80028698 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_2_4_CrntTar "value" VALUE 0x80028694 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_28 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_2_4_DitherAmp "value" VALUE 0x80028690 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_28 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_2_4_DitherFrq "value" VALUE 0x8002868C DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_29 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_2_4_PwmDuty "value" VALUE 0x80028688 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_2_5_CrntTar "value" VALUE 0x80028684 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_28 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_2_5_DitherAmp "value" VALUE 0x80028680 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_28 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_2_5_DitherFrq "value" VALUE 0x8002867C DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_29 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_2_5_PwmDuty "value" VALUE 0x80028678 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_3_6_CrntTar "value" VALUE 0x80028674 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_28 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_3_6_DitherAmp "value" VALUE 0x80028670 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_28 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_3_6_DitherFrq "value" VALUE 0x8002866C DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_29 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_3_6_PwmDuty "value" VALUE 0x80028668 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_3_7_CrntTar "value" VALUE 0x80028664 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_28 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_3_7_DitherAmp "value" VALUE 0x80028660 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_28 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_3_7_DitherFrq "value" VALUE 0x8002865C DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_29 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_3_7_PwmDuty "value" VALUE 0x80028658 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_3_8_CrntTar "value" VALUE 0x80028654 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_28 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_3_8_DitherAmp "value" VALUE 0x80028650 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_28 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_3_8_DitherFrq "value" VALUE 0x8002864C DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_29 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_3_8_PwmDuty "value" VALUE 0x80028648 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_4_10_CrntTar "value" VALUE 0x80028644 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_28 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_4_10_DitherAmp "value" VALUE 0x80028640 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_28 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_4_10_DitherFrq "value" VALUE 0x8002863C DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_29 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_4_10_PwmDuty "value" VALUE 0x80028638 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_4_9_CrntTar "value" VALUE 0x80028634 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_28 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_4_9_DitherAmp "value" VALUE 0x80028630 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_28 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_4_9_DitherFrq "value" VALUE 0x8002862C DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_29 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_LINEAR_VALVE_4_9_PwmDuty "value" VALUE 0x80028628 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_PWM_VALVE_1_1_CrntTar "value" VALUE 0x80028624 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_28 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_PWM_VALVE_1_1_DitherAmp "value" VALUE 0x80028620 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_28 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_PWM_VALVE_1_1_DitherFrq "value" VALUE 0x8002861C DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_29 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_PWM_VALVE_1_1_PwmDuty "value" VALUE 0x80028618 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_PWM_VALVE_1_2_CrntTar "value" VALUE 0x80028614 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_28 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_PWM_VALVE_1_2_DitherAmp "value" VALUE 0x80028610 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_28 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_PWM_VALVE_1_2_DitherFrq "value" VALUE 0x8002860C DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_29 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_PWM_VALVE_1_2_PwmDuty "value" VALUE 0x80028608 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_PWM_VALVE_1_3_CrntTar "value" VALUE 0x80028604 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_28 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_PWM_VALVE_1_3_DitherAmp "value" VALUE 0x80028600 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_28 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_PWM_VALVE_1_3_DitherFrq "value" VALUE 0x800285FC DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_29 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_PWM_VALVE_1_3_PwmDuty "value" VALUE 0x800285F8 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_PWM_VALVE_4_4_CrntTar "value" VALUE 0x800285F4 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_28 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_PWM_VALVE_4_4_DitherAmp "value" VALUE 0x800285F0 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_28 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_PWM_VALVE_4_4_DitherFrq "value" VALUE 0x800285EC DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_29 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_PWM_VALVE_4_4_PwmDuty "value" VALUE 0x800285E8 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_PWM_VALVE_4_5_CrntTar "value" VALUE 0x800285E4 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_28 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_PWM_VALVE_4_5_DitherAmp "value" VALUE 0x800285E0 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_28 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_PWM_VALVE_4_5_DitherFrq "value" VALUE 0x800285DC DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 F_1_p1_29 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_f32TLE8242_PWM_VALVE_4_5_PwmDuty "value" VALUE 0x800285D8 DATA_RECORD_FLOAT32_IEEE 3.402823466E+038 I_5 -3.402823466E+038 3.402823466E+038 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kau8FimDemEveStsCmd "Last test done" CURVE 0x80028367 DATA_RECORD_UBYTE 255 I_5 0 255
 /begin AXIS_DESCR FIX_AXIS NO_INPUT_QUANTITY Id_0x00 355 0 354 MAX_GRAD 100.0 FIX_AXIS_PAR_DIST 0 1 355 /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbAdcTstEnaC "Activate Adc tests" VALUE 0x80028366 DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbBtt6020TstEnaC "Activate Tle62X0 tests" VALUE 0x80028365 DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbCalibTstEnaC "Activate Tle62X0 tests" VALUE 0x80028364 DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbComTstEnaC "Activate Com tests" VALUE 0x80028363 DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbDiagcTstEnaC "Activate Tle62X0 tests" VALUE 0x80028362 DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbDioTstEnaC "Activate Dio tests" VALUE 0x80028361 DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbDioWrBtt6030Den1 "Change output state" VALUE 0x80028360 DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbDioWrBtt6030Den2 "Change output state" VALUE 0x8002835F DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbDioWrBtt6030Dsel1 "Change output state" VALUE 0x8002835E DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbDioWrBtt6030Dsel2 "Change output state" VALUE 0x8002835D DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbDioWrDselCtrl "Change output state" VALUE 0x8002835C DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbDioWrMaxShdn "Change output state" VALUE 0x8002835B DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbDioWrOutHsd1Cmd "Change output state" VALUE 0x8002835A DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbDioWrOutHsd2Cmd "Change output state" VALUE 0x80028359 DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbDioWrOutHsd3Cmd "Change output state" VALUE 0x80028358 DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbDioWrOutHsd4Cmd "Change output state" VALUE 0x80028357 DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbDioWrP9vSnsSup1En "Change output state" VALUE 0x80028356 DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbDioWrP9vSnsSup21En "Change output state" VALUE 0x80028355 DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbDioWrP9vSnsSup22En "Change output state" VALUE 0x80028354 DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbDioWrPowerDownEna "Power down the tcu" VALUE 0x80028353 DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin CHARACTERISTIC SWTST_kbDioWrSolenoidHsCmd1 "Change output state" VALUE 0x80028352 DATA_RECORD_UBYTE 1 Bool_ON_OFF 0 1 BIT_MASK 0x01 /end CHARACTERISTIC
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0102 "SWTST_udtDcmCallBackDidRdCond0102" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600111C3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0103 "SWTST_udtDcmCallBackDidRdCond0103" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600111C2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0104 "SWTST_udtDcmCallBackDidRdCond0104" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600111C1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0105 "SWTST_udtDcmCallBackDidRdCond0105" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600111C0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0106 "SWTST_udtDcmCallBackDidRdCond0106" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600111BF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0107 "SWTST_udtDcmCallBackDidRdCond0107" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600111BE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0108 "SWTST_udtDcmCallBackDidRdCond0108" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600111BD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0109 "SWTST_udtDcmCallBackDidRdCond0109" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600111BC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond010A "SWTST_udtDcmCallBackDidRdCond010A" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600111BB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond010B "SWTST_udtDcmCallBackDidRdCond010B" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600111BA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond010C "SWTST_udtDcmCallBackDidRdCond010C" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600111B9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond010D "SWTST_udtDcmCallBackDidRdCond010D" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600111B8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond010E "SWTST_udtDcmCallBackDidRdCond010E" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600111B7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond010F "SWTST_udtDcmCallBackDidRdCond010F" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600111B6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0110 "SWTST_udtDcmCallBackDidRdCond0110" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600111B5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0111 "SWTST_udtDcmCallBackDidRdCond0111" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600111B4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0112 "SWTST_udtDcmCallBackDidRdCond0112" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600111B3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0113 "SWTST_udtDcmCallBackDidRdCond0113" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600111B2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0114 "SWTST_udtDcmCallBackDidRdCond0114" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600111B1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0115 "SWTST_udtDcmCallBackDidRdCond0115" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600111B0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0116 "SWTST_udtDcmCallBackDidRdCond0116" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600111AF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0130 "SWTST_udtDcmCallBackDidRdCond0130" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600111AE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0300 "SWTST_udtDcmCallBackDidRdCond0300" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600111AD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0301 "SWTST_udtDcmCallBackDidRdCond0301" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600111AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0302 "SWTST_udtDcmCallBackDidRdCond0302" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600111AB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0303 "SWTST_udtDcmCallBackDidRdCond0303" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600111AA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0304 "SWTST_udtDcmCallBackDidRdCond0304" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600111A9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0305 "SWTST_udtDcmCallBackDidRdCond0305" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600111A8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0306 "SWTST_udtDcmCallBackDidRdCond0306" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600111A7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0307 "SWTST_udtDcmCallBackDidRdCond0307" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600111A6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0308 "SWTST_udtDcmCallBackDidRdCond0308" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600111A5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0309 "SWTST_udtDcmCallBackDidRdCond0309" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600111A4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0310 "SWTST_udtDcmCallBackDidRdCond0310" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600111A3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0311 "SWTST_udtDcmCallBackDidRdCond0311" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600111A2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0312 "SWTST_udtDcmCallBackDidRdCond0312" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600111A1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0313 "SWTST_udtDcmCallBackDidRdCond0313" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600111A0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0314 "SWTST_udtDcmCallBackDidRdCond0314" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001119F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0315 "SWTST_udtDcmCallBackDidRdCond0315" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001119E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0316 "SWTST_udtDcmCallBackDidRdCond0316" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001119D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0317 "SWTST_udtDcmCallBackDidRdCond0317" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001119C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0318 "SWTST_udtDcmCallBackDidRdCond0318" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001119B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0319 "SWTST_udtDcmCallBackDidRdCond0319" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001119A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0320 "SWTST_udtDcmCallBackDidRdCond0320" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011199 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0321 "SWTST_udtDcmCallBackDidRdCond0321" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011198 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0322 "SWTST_udtDcmCallBackDidRdCond0322" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011197 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0400 "SWTST_udtDcmCallBackDidRdCond0400" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011196 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0401 "SWTST_udtDcmCallBackDidRdCond0401" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011195 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0402 "SWTST_udtDcmCallBackDidRdCond0402" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011194 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0403 "SWTST_udtDcmCallBackDidRdCond0403" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011193 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0404 "SWTST_udtDcmCallBackDidRdCond0404" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011192 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0405 "SWTST_udtDcmCallBackDidRdCond0405" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011191 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0406 "SWTST_udtDcmCallBackDidRdCond0406" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011190 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCond0407 "SWTST_udtDcmCallBackDidRdCond0407" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001118F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCondF190 "SWTST_udtDcmCallBackDidRdCondF190" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001118E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidRdCondF195 "SWTST_udtDcmCallBackDidRdCondF195" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001118D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidWrCond0130 "SWTST_udtDcmCallBackDidWrCond0130" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001118C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidWrCond0200 "SWTST_udtDcmCallBackDidWrCond0200" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001118B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidWrCond0201 "SWTST_udtDcmCallBackDidWrCond0201" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001118A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidWrCond0202 "SWTST_udtDcmCallBackDidWrCond0202" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011189 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidWrCond0203 "SWTST_udtDcmCallBackDidWrCond0203" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011188 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidWrCond0204 "SWTST_udtDcmCallBackDidWrCond0204" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011187 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidWrCond0205 "SWTST_udtDcmCallBackDidWrCond0205" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011186 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidWrCond0206 "SWTST_udtDcmCallBackDidWrCond0206" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011185 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidWrCond0207 "SWTST_udtDcmCallBackDidWrCond0207" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011184 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidWrCond0208 "SWTST_udtDcmCallBackDidWrCond0208" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011183 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidWrCond0209 "SWTST_udtDcmCallBackDidWrCond0209" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011182 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidWrCond0403 "SWTST_udtDcmCallBackDidWrCond0403" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011181 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidWrCond0404 "SWTST_udtDcmCallBackDidWrCond0404" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011180 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidWrCond0405 "SWTST_udtDcmCallBackDidWrCond0405" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001117F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidWrCond0406 "SWTST_udtDcmCallBackDidWrCond0406" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001117E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidWrCondF190 "SWTST_udtDcmCallBackDidWrCondF190" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001117D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmCallBackDidWrCondF195 "SWTST_udtDcmCallBackDidWrCondF195" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001117C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType04 "SWTST_udtDcmDidForRdInfoType04" UBYTE I_5 1 2 0 255 MATRIX_DIM 17 1 1 ECU_ADDRESS 0x6001116B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType04[0] "SWTST_udtDcmDidForRdInfoType04[0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001116B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType04[10] "SWTST_udtDcmDidForRdInfoType04[10]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011175 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType04[11] "SWTST_udtDcmDidForRdInfoType04[11]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011176 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType04[12] "SWTST_udtDcmDidForRdInfoType04[12]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011177 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType04[13] "SWTST_udtDcmDidForRdInfoType04[13]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011178 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType04[14] "SWTST_udtDcmDidForRdInfoType04[14]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011179 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType04[15] "SWTST_udtDcmDidForRdInfoType04[15]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001117A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType04[16] "SWTST_udtDcmDidForRdInfoType04[16]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001117B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType04[1] "SWTST_udtDcmDidForRdInfoType04[1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001116C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType04[2] "SWTST_udtDcmDidForRdInfoType04[2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001116D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType04[3] "SWTST_udtDcmDidForRdInfoType04[3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001116E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType04[4] "SWTST_udtDcmDidForRdInfoType04[4]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001116F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType04[5] "SWTST_udtDcmDidForRdInfoType04[5]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011170 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType04[6] "SWTST_udtDcmDidForRdInfoType04[6]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011171 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType04[7] "SWTST_udtDcmDidForRdInfoType04[7]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011172 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType04[8] "SWTST_udtDcmDidForRdInfoType04[8]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011173 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType04[9] "SWTST_udtDcmDidForRdInfoType04[9]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011174 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType06 "SWTST_udtDcmDidForRdInfoType06" UBYTE I_5 1 2 0 255 MATRIX_DIM 3 1 1 ECU_ADDRESS 0x60011168 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType06[0] "SWTST_udtDcmDidForRdInfoType06[0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011168 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType06[1] "SWTST_udtDcmDidForRdInfoType06[1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011169 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType06[2] "SWTST_udtDcmDidForRdInfoType06[2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001116A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType0A "SWTST_udtDcmDidForRdInfoType0A" UBYTE I_5 1 2 0 255 MATRIX_DIM 21 1 1 ECU_ADDRESS 0x60011153 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType0A[0] "SWTST_udtDcmDidForRdInfoType0A[0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011153 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType0A[10] "SWTST_udtDcmDidForRdInfoType0A[10]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001115D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType0A[11] "SWTST_udtDcmDidForRdInfoType0A[11]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001115E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType0A[12] "SWTST_udtDcmDidForRdInfoType0A[12]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001115F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType0A[13] "SWTST_udtDcmDidForRdInfoType0A[13]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011160 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType0A[14] "SWTST_udtDcmDidForRdInfoType0A[14]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011161 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType0A[15] "SWTST_udtDcmDidForRdInfoType0A[15]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011162 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType0A[16] "SWTST_udtDcmDidForRdInfoType0A[16]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011163 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType0A[17] "SWTST_udtDcmDidForRdInfoType0A[17]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011164 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType0A[18] "SWTST_udtDcmDidForRdInfoType0A[18]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011165 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType0A[19] "SWTST_udtDcmDidForRdInfoType0A[19]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011166 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType0A[1] "SWTST_udtDcmDidForRdInfoType0A[1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011154 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType0A[20] "SWTST_udtDcmDidForRdInfoType0A[20]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011167 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType0A[2] "SWTST_udtDcmDidForRdInfoType0A[2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011155 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType0A[3] "SWTST_udtDcmDidForRdInfoType0A[3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011156 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType0A[4] "SWTST_udtDcmDidForRdInfoType0A[4]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011157 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType0A[5] "SWTST_udtDcmDidForRdInfoType0A[5]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011158 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType0A[6] "SWTST_udtDcmDidForRdInfoType0A[6]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011159 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType0A[7] "SWTST_udtDcmDidForRdInfoType0A[7]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001115A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType0A[8] "SWTST_udtDcmDidForRdInfoType0A[8]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001115B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmDidForRdInfoType0A[9] "SWTST_udtDcmDidForRdInfoType0A[9]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001115C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData "SWTST_udtDcmReqData" UBYTE I_5 1 2 0 255 MATRIX_DIM 200 1 1 ECU_ADDRESS 0x6001108B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqDataSa "SWTST_udtDcmReqDataSa" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010DE2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqDataSize "SWTST_udtDcmReqDataSize" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010DE0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[0] "SWTST_udtDcmReqData[0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001108B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[100] "SWTST_udtDcmReqData[100]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110EF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[101] "SWTST_udtDcmReqData[101]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110F0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[102] "SWTST_udtDcmReqData[102]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110F1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[103] "SWTST_udtDcmReqData[103]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110F2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[104] "SWTST_udtDcmReqData[104]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110F3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[105] "SWTST_udtDcmReqData[105]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110F4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[106] "SWTST_udtDcmReqData[106]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110F5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[107] "SWTST_udtDcmReqData[107]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110F6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[108] "SWTST_udtDcmReqData[108]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110F7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[109] "SWTST_udtDcmReqData[109]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110F8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[10] "SWTST_udtDcmReqData[10]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011095 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[110] "SWTST_udtDcmReqData[110]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110F9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[111] "SWTST_udtDcmReqData[111]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110FA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[112] "SWTST_udtDcmReqData[112]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110FB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[113] "SWTST_udtDcmReqData[113]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110FC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[114] "SWTST_udtDcmReqData[114]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110FD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[115] "SWTST_udtDcmReqData[115]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110FE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[116] "SWTST_udtDcmReqData[116]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110FF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[117] "SWTST_udtDcmReqData[117]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011100 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[118] "SWTST_udtDcmReqData[118]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011101 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[119] "SWTST_udtDcmReqData[119]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011102 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[11] "SWTST_udtDcmReqData[11]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011096 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[120] "SWTST_udtDcmReqData[120]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011103 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[121] "SWTST_udtDcmReqData[121]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011104 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[122] "SWTST_udtDcmReqData[122]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011105 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[123] "SWTST_udtDcmReqData[123]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011106 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[124] "SWTST_udtDcmReqData[124]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011107 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[125] "SWTST_udtDcmReqData[125]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011108 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[126] "SWTST_udtDcmReqData[126]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011109 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[127] "SWTST_udtDcmReqData[127]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001110A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[128] "SWTST_udtDcmReqData[128]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001110B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[129] "SWTST_udtDcmReqData[129]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001110C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[12] "SWTST_udtDcmReqData[12]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011097 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[130] "SWTST_udtDcmReqData[130]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001110D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[131] "SWTST_udtDcmReqData[131]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001110E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[132] "SWTST_udtDcmReqData[132]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001110F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[133] "SWTST_udtDcmReqData[133]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011110 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[134] "SWTST_udtDcmReqData[134]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011111 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[135] "SWTST_udtDcmReqData[135]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011112 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[136] "SWTST_udtDcmReqData[136]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011113 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[137] "SWTST_udtDcmReqData[137]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011114 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[138] "SWTST_udtDcmReqData[138]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011115 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[139] "SWTST_udtDcmReqData[139]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011116 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[13] "SWTST_udtDcmReqData[13]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011098 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[140] "SWTST_udtDcmReqData[140]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011117 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[141] "SWTST_udtDcmReqData[141]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011118 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[142] "SWTST_udtDcmReqData[142]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011119 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[143] "SWTST_udtDcmReqData[143]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001111A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[144] "SWTST_udtDcmReqData[144]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001111B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[145] "SWTST_udtDcmReqData[145]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001111C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[146] "SWTST_udtDcmReqData[146]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001111D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[147] "SWTST_udtDcmReqData[147]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001111E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[148] "SWTST_udtDcmReqData[148]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001111F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[149] "SWTST_udtDcmReqData[149]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011120 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[14] "SWTST_udtDcmReqData[14]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011099 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[150] "SWTST_udtDcmReqData[150]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011121 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[151] "SWTST_udtDcmReqData[151]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011122 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[152] "SWTST_udtDcmReqData[152]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011123 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[153] "SWTST_udtDcmReqData[153]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011124 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[154] "SWTST_udtDcmReqData[154]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011125 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[155] "SWTST_udtDcmReqData[155]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011126 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[156] "SWTST_udtDcmReqData[156]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011127 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[157] "SWTST_udtDcmReqData[157]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011128 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[158] "SWTST_udtDcmReqData[158]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011129 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[159] "SWTST_udtDcmReqData[159]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001112A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[15] "SWTST_udtDcmReqData[15]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001109A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[160] "SWTST_udtDcmReqData[160]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001112B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[161] "SWTST_udtDcmReqData[161]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001112C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[162] "SWTST_udtDcmReqData[162]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001112D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[163] "SWTST_udtDcmReqData[163]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001112E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[164] "SWTST_udtDcmReqData[164]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001112F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[165] "SWTST_udtDcmReqData[165]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011130 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[166] "SWTST_udtDcmReqData[166]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011131 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[167] "SWTST_udtDcmReqData[167]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011132 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[168] "SWTST_udtDcmReqData[168]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011133 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[169] "SWTST_udtDcmReqData[169]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011134 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[16] "SWTST_udtDcmReqData[16]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001109B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[170] "SWTST_udtDcmReqData[170]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011135 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[171] "SWTST_udtDcmReqData[171]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011136 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[172] "SWTST_udtDcmReqData[172]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011137 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[173] "SWTST_udtDcmReqData[173]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011138 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[174] "SWTST_udtDcmReqData[174]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011139 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[175] "SWTST_udtDcmReqData[175]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001113A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[176] "SWTST_udtDcmReqData[176]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001113B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[177] "SWTST_udtDcmReqData[177]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001113C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[178] "SWTST_udtDcmReqData[178]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001113D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[179] "SWTST_udtDcmReqData[179]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001113E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[17] "SWTST_udtDcmReqData[17]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001109C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[180] "SWTST_udtDcmReqData[180]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001113F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[181] "SWTST_udtDcmReqData[181]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011140 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[182] "SWTST_udtDcmReqData[182]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011141 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[183] "SWTST_udtDcmReqData[183]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011142 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[184] "SWTST_udtDcmReqData[184]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011143 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[185] "SWTST_udtDcmReqData[185]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011144 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[186] "SWTST_udtDcmReqData[186]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011145 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[187] "SWTST_udtDcmReqData[187]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011146 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[188] "SWTST_udtDcmReqData[188]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011147 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[189] "SWTST_udtDcmReqData[189]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011148 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[18] "SWTST_udtDcmReqData[18]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001109D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[190] "SWTST_udtDcmReqData[190]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011149 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[191] "SWTST_udtDcmReqData[191]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001114A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[192] "SWTST_udtDcmReqData[192]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001114B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[193] "SWTST_udtDcmReqData[193]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001114C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[194] "SWTST_udtDcmReqData[194]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001114D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[195] "SWTST_udtDcmReqData[195]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001114E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[196] "SWTST_udtDcmReqData[196]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001114F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[197] "SWTST_udtDcmReqData[197]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011150 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[198] "SWTST_udtDcmReqData[198]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011151 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[199] "SWTST_udtDcmReqData[199]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011152 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[19] "SWTST_udtDcmReqData[19]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001109E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[1] "SWTST_udtDcmReqData[1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001108C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[20] "SWTST_udtDcmReqData[20]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001109F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[21] "SWTST_udtDcmReqData[21]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110A0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[22] "SWTST_udtDcmReqData[22]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110A1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[23] "SWTST_udtDcmReqData[23]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110A2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[24] "SWTST_udtDcmReqData[24]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110A3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[25] "SWTST_udtDcmReqData[25]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110A4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[26] "SWTST_udtDcmReqData[26]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110A5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[27] "SWTST_udtDcmReqData[27]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110A6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[28] "SWTST_udtDcmReqData[28]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110A7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[29] "SWTST_udtDcmReqData[29]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110A8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[2] "SWTST_udtDcmReqData[2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001108D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[30] "SWTST_udtDcmReqData[30]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110A9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[31] "SWTST_udtDcmReqData[31]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110AA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[32] "SWTST_udtDcmReqData[32]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110AB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[33] "SWTST_udtDcmReqData[33]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[34] "SWTST_udtDcmReqData[34]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110AD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[35] "SWTST_udtDcmReqData[35]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110AE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[36] "SWTST_udtDcmReqData[36]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110AF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[37] "SWTST_udtDcmReqData[37]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110B0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[38] "SWTST_udtDcmReqData[38]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110B1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[39] "SWTST_udtDcmReqData[39]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110B2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[3] "SWTST_udtDcmReqData[3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001108E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[40] "SWTST_udtDcmReqData[40]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110B3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[41] "SWTST_udtDcmReqData[41]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110B4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[42] "SWTST_udtDcmReqData[42]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110B5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[43] "SWTST_udtDcmReqData[43]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110B6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[44] "SWTST_udtDcmReqData[44]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110B7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[45] "SWTST_udtDcmReqData[45]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110B8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[46] "SWTST_udtDcmReqData[46]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110B9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[47] "SWTST_udtDcmReqData[47]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110BA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[48] "SWTST_udtDcmReqData[48]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110BB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[49] "SWTST_udtDcmReqData[49]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110BC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[4] "SWTST_udtDcmReqData[4]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001108F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[50] "SWTST_udtDcmReqData[50]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110BD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[51] "SWTST_udtDcmReqData[51]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110BE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[52] "SWTST_udtDcmReqData[52]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110BF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[53] "SWTST_udtDcmReqData[53]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110C0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[54] "SWTST_udtDcmReqData[54]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110C1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[55] "SWTST_udtDcmReqData[55]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110C2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[56] "SWTST_udtDcmReqData[56]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110C3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[57] "SWTST_udtDcmReqData[57]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110C4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[58] "SWTST_udtDcmReqData[58]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110C5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[59] "SWTST_udtDcmReqData[59]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110C6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[5] "SWTST_udtDcmReqData[5]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011090 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[60] "SWTST_udtDcmReqData[60]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110C7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[61] "SWTST_udtDcmReqData[61]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110C8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[62] "SWTST_udtDcmReqData[62]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110C9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[63] "SWTST_udtDcmReqData[63]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110CA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[64] "SWTST_udtDcmReqData[64]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110CB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[65] "SWTST_udtDcmReqData[65]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110CC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[66] "SWTST_udtDcmReqData[66]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110CD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[67] "SWTST_udtDcmReqData[67]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110CE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[68] "SWTST_udtDcmReqData[68]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110CF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[69] "SWTST_udtDcmReqData[69]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110D0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[6] "SWTST_udtDcmReqData[6]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011091 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[70] "SWTST_udtDcmReqData[70]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110D1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[71] "SWTST_udtDcmReqData[71]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110D2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[72] "SWTST_udtDcmReqData[72]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110D3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[73] "SWTST_udtDcmReqData[73]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110D4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[74] "SWTST_udtDcmReqData[74]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110D5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[75] "SWTST_udtDcmReqData[75]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110D6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[76] "SWTST_udtDcmReqData[76]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110D7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[77] "SWTST_udtDcmReqData[77]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110D8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[78] "SWTST_udtDcmReqData[78]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110D9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[79] "SWTST_udtDcmReqData[79]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110DA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[7] "SWTST_udtDcmReqData[7]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011092 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[80] "SWTST_udtDcmReqData[80]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110DB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[81] "SWTST_udtDcmReqData[81]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110DC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[82] "SWTST_udtDcmReqData[82]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110DD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[83] "SWTST_udtDcmReqData[83]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110DE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[84] "SWTST_udtDcmReqData[84]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110DF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[85] "SWTST_udtDcmReqData[85]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110E0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[86] "SWTST_udtDcmReqData[86]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110E1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[87] "SWTST_udtDcmReqData[87]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110E2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[88] "SWTST_udtDcmReqData[88]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110E3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[89] "SWTST_udtDcmReqData[89]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110E4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[8] "SWTST_udtDcmReqData[8]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011093 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[90] "SWTST_udtDcmReqData[90]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110E5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[91] "SWTST_udtDcmReqData[91]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110E6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[92] "SWTST_udtDcmReqData[92]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110E7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[93] "SWTST_udtDcmReqData[93]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110E8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[94] "SWTST_udtDcmReqData[94]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110E9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[95] "SWTST_udtDcmReqData[95]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110EA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[96] "SWTST_udtDcmReqData[96]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110EB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[97] "SWTST_udtDcmReqData[97]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110EC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[98] "SWTST_udtDcmReqData[98]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110ED READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[99] "SWTST_udtDcmReqData[99]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600110EE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqData[9] "SWTST_udtDcmReqData[9]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011094 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqErrCode "SWTST_udtDcmReqErrCode" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001108A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqSid "SWTST_udtDcmReqSid" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011089 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_udtDcmReqType "SWTST_udtDcmReqType" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011088 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vau8Btt6020OcFltTst "solenoid over load status" UBYTE I_5 1 2 0 255 MATRIX_DIM 4 1 1 ECU_ADDRESS 0x60011084 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vau8Btt6020OcFltTst[0] "SWTST_vau8Btt6020OcFltTst[0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011084 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vau8Btt6020OcFltTst[1] "SWTST_vau8Btt6020OcFltTst[1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011085 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vau8Btt6020OcFltTst[2] "SWTST_vau8Btt6020OcFltTst[2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011086 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vau8Btt6020OcFltTst[3] "SWTST_vau8Btt6020OcFltTst[3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011087 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vbAdcTstDone "Test sequence is done" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A69 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vbAdcTstErr "Result of the test" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A68 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vbBtt6020TstDone "Test sequence is done" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A67 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vbBtt6020TstErr "Result of the test" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A66 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vbCalibTstDone "Test sequence is done" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A65 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vbCalibTstErr "Result of the test" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A64 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vbComTstDone "Test sequence is done" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A63 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vbComTstErr "Result of the test" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A62 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vbDiagcTstDone "Test sequence is done" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A61 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vbDiagcTstErr "Result of the test" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A60 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vbDioTstDone "Test sequence is done" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A5F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vbDioTstErr "Result of the test" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A5E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vbFimTstDone "Test sequence is done" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A5D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vbFimTstErr "Result of the test" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A5C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vbSftyTstDone "Test sequence is done" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A5B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vbSftyTstErr "Result of the test" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A5A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vbTle62X0TstDone "Test sequence is done" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A59 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vbTle62X0TstErr "Result of the test" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A58 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vbTle8242TstDone "Test sequence is done" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A57 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vbTle8242TstErr "Result of the test" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A56 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vbTrimTstDone "Test sequence is done" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A55 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vbTrimTstErr "Result of the test" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A54 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vbWdgTstDone "Test sequence is done" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A53 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vbWdgTstErr "Result of the test" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A52 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt "lost communication counter" UBYTE I_5 1 2 0 255 MATRIX_DIM 73 1 1 ECU_ADDRESS 0x6001103B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[0] "SWTST_vidDiagcCalCnt[0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001103B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[10] "SWTST_vidDiagcCalCnt[10]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011045 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[11] "SWTST_vidDiagcCalCnt[11]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011046 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[12] "SWTST_vidDiagcCalCnt[12]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011047 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[13] "SWTST_vidDiagcCalCnt[13]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011048 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[14] "SWTST_vidDiagcCalCnt[14]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011049 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[15] "SWTST_vidDiagcCalCnt[15]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001104A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[16] "SWTST_vidDiagcCalCnt[16]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001104B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[17] "SWTST_vidDiagcCalCnt[17]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001104C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[18] "SWTST_vidDiagcCalCnt[18]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001104D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[19] "SWTST_vidDiagcCalCnt[19]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001104E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[1] "SWTST_vidDiagcCalCnt[1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001103C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[20] "SWTST_vidDiagcCalCnt[20]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001104F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[21] "SWTST_vidDiagcCalCnt[21]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011050 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[22] "SWTST_vidDiagcCalCnt[22]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011051 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[23] "SWTST_vidDiagcCalCnt[23]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011052 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[24] "SWTST_vidDiagcCalCnt[24]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011053 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[25] "SWTST_vidDiagcCalCnt[25]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011054 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[26] "SWTST_vidDiagcCalCnt[26]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011055 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[27] "SWTST_vidDiagcCalCnt[27]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011056 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[28] "SWTST_vidDiagcCalCnt[28]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011057 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[29] "SWTST_vidDiagcCalCnt[29]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011058 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[2] "SWTST_vidDiagcCalCnt[2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001103D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[30] "SWTST_vidDiagcCalCnt[30]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011059 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[31] "SWTST_vidDiagcCalCnt[31]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001105A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[32] "SWTST_vidDiagcCalCnt[32]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001105B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[33] "SWTST_vidDiagcCalCnt[33]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001105C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[34] "SWTST_vidDiagcCalCnt[34]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001105D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[35] "SWTST_vidDiagcCalCnt[35]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001105E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[36] "SWTST_vidDiagcCalCnt[36]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001105F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[37] "SWTST_vidDiagcCalCnt[37]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011060 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[38] "SWTST_vidDiagcCalCnt[38]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011061 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[39] "SWTST_vidDiagcCalCnt[39]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011062 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[3] "SWTST_vidDiagcCalCnt[3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001103E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[40] "SWTST_vidDiagcCalCnt[40]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011063 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[41] "SWTST_vidDiagcCalCnt[41]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011064 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[42] "SWTST_vidDiagcCalCnt[42]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011065 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[43] "SWTST_vidDiagcCalCnt[43]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011066 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[44] "SWTST_vidDiagcCalCnt[44]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011067 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[45] "SWTST_vidDiagcCalCnt[45]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011068 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[46] "SWTST_vidDiagcCalCnt[46]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011069 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[47] "SWTST_vidDiagcCalCnt[47]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001106A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[48] "SWTST_vidDiagcCalCnt[48]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001106B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[49] "SWTST_vidDiagcCalCnt[49]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001106C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[4] "SWTST_vidDiagcCalCnt[4]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001103F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[50] "SWTST_vidDiagcCalCnt[50]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001106D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[51] "SWTST_vidDiagcCalCnt[51]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001106E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[52] "SWTST_vidDiagcCalCnt[52]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001106F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[53] "SWTST_vidDiagcCalCnt[53]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011070 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[54] "SWTST_vidDiagcCalCnt[54]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011071 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[55] "SWTST_vidDiagcCalCnt[55]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011072 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[56] "SWTST_vidDiagcCalCnt[56]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011073 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[57] "SWTST_vidDiagcCalCnt[57]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011074 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[58] "SWTST_vidDiagcCalCnt[58]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011075 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[59] "SWTST_vidDiagcCalCnt[59]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011076 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[5] "SWTST_vidDiagcCalCnt[5]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011040 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[60] "SWTST_vidDiagcCalCnt[60]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011077 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[61] "SWTST_vidDiagcCalCnt[61]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011078 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[62] "SWTST_vidDiagcCalCnt[62]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011079 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[63] "SWTST_vidDiagcCalCnt[63]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001107A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[64] "SWTST_vidDiagcCalCnt[64]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001107B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[65] "SWTST_vidDiagcCalCnt[65]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001107C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[66] "SWTST_vidDiagcCalCnt[66]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001107D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[67] "SWTST_vidDiagcCalCnt[67]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001107E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[68] "SWTST_vidDiagcCalCnt[68]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001107F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[69] "SWTST_vidDiagcCalCnt[69]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011080 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[6] "SWTST_vidDiagcCalCnt[6]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011041 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[70] "SWTST_vidDiagcCalCnt[70]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011081 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[71] "SWTST_vidDiagcCalCnt[71]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011082 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[72] "SWTST_vidDiagcCalCnt[72]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011083 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[7] "SWTST_vidDiagcCalCnt[7]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011042 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[8] "SWTST_vidDiagcCalCnt[8]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011043 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcCalCnt[9] "SWTST_vidDiagcCalCnt[9]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011044 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcDecTstEn "SWTST_vidDiagcDecTstEn" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010DDE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt "lost communication counter" UBYTE I_5 1 2 0 255 MATRIX_DIM 67 1 1 ECU_ADDRESS 0x60010FF8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg "lost communication counter flag" UBYTE I_5 1 2 0 255 MATRIX_DIM 67 1 1 ECU_ADDRESS 0x60010FB5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[0] "SWTST_vidDiagcMaxCntFlg[0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FB5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[10] "SWTST_vidDiagcMaxCntFlg[10]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FBF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[11] "SWTST_vidDiagcMaxCntFlg[11]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FC0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[12] "SWTST_vidDiagcMaxCntFlg[12]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FC1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[13] "SWTST_vidDiagcMaxCntFlg[13]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FC2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[14] "SWTST_vidDiagcMaxCntFlg[14]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FC3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[15] "SWTST_vidDiagcMaxCntFlg[15]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FC4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[16] "SWTST_vidDiagcMaxCntFlg[16]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FC5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[17] "SWTST_vidDiagcMaxCntFlg[17]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FC6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[18] "SWTST_vidDiagcMaxCntFlg[18]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FC7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[19] "SWTST_vidDiagcMaxCntFlg[19]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FC8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[1] "SWTST_vidDiagcMaxCntFlg[1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FB6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[20] "SWTST_vidDiagcMaxCntFlg[20]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FC9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[21] "SWTST_vidDiagcMaxCntFlg[21]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FCA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[22] "SWTST_vidDiagcMaxCntFlg[22]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FCB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[23] "SWTST_vidDiagcMaxCntFlg[23]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FCC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[24] "SWTST_vidDiagcMaxCntFlg[24]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FCD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[25] "SWTST_vidDiagcMaxCntFlg[25]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FCE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[26] "SWTST_vidDiagcMaxCntFlg[26]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FCF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[27] "SWTST_vidDiagcMaxCntFlg[27]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FD0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[28] "SWTST_vidDiagcMaxCntFlg[28]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FD1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[29] "SWTST_vidDiagcMaxCntFlg[29]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FD2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[2] "SWTST_vidDiagcMaxCntFlg[2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FB7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[30] "SWTST_vidDiagcMaxCntFlg[30]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FD3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[31] "SWTST_vidDiagcMaxCntFlg[31]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FD4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[32] "SWTST_vidDiagcMaxCntFlg[32]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FD5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[33] "SWTST_vidDiagcMaxCntFlg[33]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FD6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[34] "SWTST_vidDiagcMaxCntFlg[34]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FD7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[35] "SWTST_vidDiagcMaxCntFlg[35]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FD8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[36] "SWTST_vidDiagcMaxCntFlg[36]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FD9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[37] "SWTST_vidDiagcMaxCntFlg[37]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FDA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[38] "SWTST_vidDiagcMaxCntFlg[38]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FDB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[39] "SWTST_vidDiagcMaxCntFlg[39]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FDC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[3] "SWTST_vidDiagcMaxCntFlg[3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FB8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[40] "SWTST_vidDiagcMaxCntFlg[40]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FDD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[41] "SWTST_vidDiagcMaxCntFlg[41]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FDE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[42] "SWTST_vidDiagcMaxCntFlg[42]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FDF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[43] "SWTST_vidDiagcMaxCntFlg[43]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FE0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[44] "SWTST_vidDiagcMaxCntFlg[44]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FE1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[45] "SWTST_vidDiagcMaxCntFlg[45]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FE2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[46] "SWTST_vidDiagcMaxCntFlg[46]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FE3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[47] "SWTST_vidDiagcMaxCntFlg[47]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FE4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[48] "SWTST_vidDiagcMaxCntFlg[48]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FE5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[49] "SWTST_vidDiagcMaxCntFlg[49]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FE6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[4] "SWTST_vidDiagcMaxCntFlg[4]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FB9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[50] "SWTST_vidDiagcMaxCntFlg[50]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FE7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[51] "SWTST_vidDiagcMaxCntFlg[51]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FE8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[52] "SWTST_vidDiagcMaxCntFlg[52]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FE9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[53] "SWTST_vidDiagcMaxCntFlg[53]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FEA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[54] "SWTST_vidDiagcMaxCntFlg[54]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FEB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[55] "SWTST_vidDiagcMaxCntFlg[55]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FEC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[56] "SWTST_vidDiagcMaxCntFlg[56]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FED READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[57] "SWTST_vidDiagcMaxCntFlg[57]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FEE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[58] "SWTST_vidDiagcMaxCntFlg[58]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FEF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[59] "SWTST_vidDiagcMaxCntFlg[59]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FF0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[5] "SWTST_vidDiagcMaxCntFlg[5]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FBA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[60] "SWTST_vidDiagcMaxCntFlg[60]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FF1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[61] "SWTST_vidDiagcMaxCntFlg[61]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FF2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[62] "SWTST_vidDiagcMaxCntFlg[62]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FF3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[63] "SWTST_vidDiagcMaxCntFlg[63]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FF4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[64] "SWTST_vidDiagcMaxCntFlg[64]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FF5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[65] "SWTST_vidDiagcMaxCntFlg[65]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FF6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[66] "SWTST_vidDiagcMaxCntFlg[66]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FF7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[6] "SWTST_vidDiagcMaxCntFlg[6]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FBB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[7] "SWTST_vidDiagcMaxCntFlg[7]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FBC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[8] "SWTST_vidDiagcMaxCntFlg[8]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FBD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCntFlg[9] "SWTST_vidDiagcMaxCntFlg[9]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FBE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[0] "SWTST_vidDiagcMaxCnt[0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FF8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[10] "SWTST_vidDiagcMaxCnt[10]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011002 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[11] "SWTST_vidDiagcMaxCnt[11]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011003 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[12] "SWTST_vidDiagcMaxCnt[12]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011004 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[13] "SWTST_vidDiagcMaxCnt[13]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011005 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[14] "SWTST_vidDiagcMaxCnt[14]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011006 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[15] "SWTST_vidDiagcMaxCnt[15]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011007 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[16] "SWTST_vidDiagcMaxCnt[16]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011008 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[17] "SWTST_vidDiagcMaxCnt[17]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011009 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[18] "SWTST_vidDiagcMaxCnt[18]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001100A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[19] "SWTST_vidDiagcMaxCnt[19]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001100B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[1] "SWTST_vidDiagcMaxCnt[1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FF9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[20] "SWTST_vidDiagcMaxCnt[20]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001100C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[21] "SWTST_vidDiagcMaxCnt[21]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001100D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[22] "SWTST_vidDiagcMaxCnt[22]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001100E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[23] "SWTST_vidDiagcMaxCnt[23]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001100F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[24] "SWTST_vidDiagcMaxCnt[24]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011010 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[25] "SWTST_vidDiagcMaxCnt[25]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011011 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[26] "SWTST_vidDiagcMaxCnt[26]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011012 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[27] "SWTST_vidDiagcMaxCnt[27]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011013 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[28] "SWTST_vidDiagcMaxCnt[28]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011014 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[29] "SWTST_vidDiagcMaxCnt[29]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011015 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[2] "SWTST_vidDiagcMaxCnt[2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FFA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[30] "SWTST_vidDiagcMaxCnt[30]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011016 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[31] "SWTST_vidDiagcMaxCnt[31]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011017 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[32] "SWTST_vidDiagcMaxCnt[32]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011018 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[33] "SWTST_vidDiagcMaxCnt[33]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011019 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[34] "SWTST_vidDiagcMaxCnt[34]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001101A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[35] "SWTST_vidDiagcMaxCnt[35]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001101B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[36] "SWTST_vidDiagcMaxCnt[36]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001101C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[37] "SWTST_vidDiagcMaxCnt[37]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001101D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[38] "SWTST_vidDiagcMaxCnt[38]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001101E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[39] "SWTST_vidDiagcMaxCnt[39]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001101F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[3] "SWTST_vidDiagcMaxCnt[3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FFB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[40] "SWTST_vidDiagcMaxCnt[40]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011020 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[41] "SWTST_vidDiagcMaxCnt[41]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011021 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[42] "SWTST_vidDiagcMaxCnt[42]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011022 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[43] "SWTST_vidDiagcMaxCnt[43]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011023 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[44] "SWTST_vidDiagcMaxCnt[44]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011024 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[45] "SWTST_vidDiagcMaxCnt[45]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011025 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[46] "SWTST_vidDiagcMaxCnt[46]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011026 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[47] "SWTST_vidDiagcMaxCnt[47]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011027 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[48] "SWTST_vidDiagcMaxCnt[48]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011028 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[49] "SWTST_vidDiagcMaxCnt[49]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011029 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[4] "SWTST_vidDiagcMaxCnt[4]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FFC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[50] "SWTST_vidDiagcMaxCnt[50]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001102A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[51] "SWTST_vidDiagcMaxCnt[51]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001102B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[52] "SWTST_vidDiagcMaxCnt[52]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001102C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[53] "SWTST_vidDiagcMaxCnt[53]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001102D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[54] "SWTST_vidDiagcMaxCnt[54]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001102E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[55] "SWTST_vidDiagcMaxCnt[55]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001102F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[56] "SWTST_vidDiagcMaxCnt[56]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011030 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[57] "SWTST_vidDiagcMaxCnt[57]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011031 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[58] "SWTST_vidDiagcMaxCnt[58]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011032 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[59] "SWTST_vidDiagcMaxCnt[59]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011033 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[5] "SWTST_vidDiagcMaxCnt[5]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FFD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[60] "SWTST_vidDiagcMaxCnt[60]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011034 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[61] "SWTST_vidDiagcMaxCnt[61]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011035 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[62] "SWTST_vidDiagcMaxCnt[62]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011036 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[63] "SWTST_vidDiagcMaxCnt[63]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011037 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[64] "SWTST_vidDiagcMaxCnt[64]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011038 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[65] "SWTST_vidDiagcMaxCnt[65]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011039 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[66] "SWTST_vidDiagcMaxCnt[66]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6001103A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[6] "SWTST_vidDiagcMaxCnt[6]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FFE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[7] "SWTST_vidDiagcMaxCnt[7]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FFF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[8] "SWTST_vidDiagcMaxCnt[8]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011000 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidDiagcMaxCnt[9] "SWTST_vidDiagcMaxCnt[9]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60011001 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vidSolCompRes "Solenoid's parameter comparison result" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A51 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu32Dm07MsgSpn "SWTST_vu32Dm07MsgSpn" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60012934 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8AdcRunngTstNr "Current test running" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FB4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8BTT6030OcFltTst "smart high side open fault status" UBYTE I_5 1 2 0 255 MATRIX_DIM 4 1 1 ECU_ADDRESS 0x60010FA3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8BTT6030OcFltTst[0] "SWTST_vu8BTT6030OcFltTst[0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FA3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8BTT6030OcFltTst[1] "SWTST_vu8BTT6030OcFltTst[1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FA4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8BTT6030OcFltTst[2] "SWTST_vu8BTT6030OcFltTst[2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FA5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8BTT6030OcFltTst[3] "SWTST_vu8BTT6030OcFltTst[3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FA6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8BTT6030ScFltTst "solenoid short to ground status" UBYTE I_5 1 2 0 255 MATRIX_DIM 4 1 1 ECU_ADDRESS 0x60010F9F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8BTT6030ScFltTst[0] "SWTST_vu8BTT6030ScFltTst[0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F9F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8BTT6030ScFltTst[1] "SWTST_vu8BTT6030ScFltTst[1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FA0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8BTT6030ScFltTst[2] "SWTST_vu8BTT6030ScFltTst[2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FA1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8BTT6030ScFltTst[3] "SWTST_vu8BTT6030ScFltTst[3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FA2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8BTT6030ScsFltTst "solenoid short to battery status" UBYTE I_5 1 2 0 255 MATRIX_DIM 4 1 1 ECU_ADDRESS 0x60010F9B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8BTT6030ScsFltTst[0] "SWTST_vu8BTT6030ScsFltTst[0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F9B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8BTT6030ScsFltTst[1] "SWTST_vu8BTT6030ScsFltTst[1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F9C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8BTT6030ScsFltTst[2] "SWTST_vu8BTT6030ScsFltTst[2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F9D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8BTT6030ScsFltTst[3] "SWTST_vu8BTT6030ScsFltTst[3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F9E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Btt6020OverLoadFltTst "solenoid over load status" UBYTE I_5 1 2 0 255 MATRIX_DIM 4 1 1 ECU_ADDRESS 0x60010FB0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Btt6020OverLoadFltTst[0] "SWTST_vu8Btt6020OverLoadFltTst[0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FB0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Btt6020OverLoadFltTst[1] "SWTST_vu8Btt6020OverLoadFltTst[1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FB1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Btt6020OverLoadFltTst[2] "SWTST_vu8Btt6020OverLoadFltTst[2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FB2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Btt6020OverLoadFltTst[3] "SWTST_vu8Btt6020OverLoadFltTst[3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FB3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Btt6020RunngTstNr "Current test running" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FAF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Btt6020ScFltTst "solenoid short to ground status" UBYTE I_5 1 2 0 255 MATRIX_DIM 4 1 1 ECU_ADDRESS 0x60010FAB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Btt6020ScFltTst[0] "SWTST_vu8Btt6020ScFltTst[0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FAB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Btt6020ScFltTst[1] "SWTST_vu8Btt6020ScFltTst[1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FAC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Btt6020ScFltTst[2] "SWTST_vu8Btt6020ScFltTst[2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FAD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Btt6020ScFltTst[3] "SWTST_vu8Btt6020ScFltTst[3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FAE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Btt6020ScsFltTst "solenoid short to battery status" UBYTE I_5 1 2 0 255 MATRIX_DIM 4 1 1 ECU_ADDRESS 0x60010FA7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Btt6020ScsFltTst[0] "SWTST_vu8Btt6020ScsFltTst[0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FA7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Btt6020ScsFltTst[1] "SWTST_vu8Btt6020ScsFltTst[1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FA8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Btt6020ScsFltTst[2] "SWTST_vu8Btt6020ScsFltTst[2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FA9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Btt6020ScsFltTst[3] "SWTST_vu8Btt6020ScsFltTst[3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010FAA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8CalibRunngTstNr "Current test running" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F9A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8ComRunngTstNr "Current test running" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F99 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8DiagcRunngTstNr "Current test running" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F98 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8DioRunngTstNr "Current test running" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F97 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm07Mod "SWTST_vu8Dm07Mod" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F96 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm07MsgFmi "SWTST_vu8Dm07MsgFmi" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F95 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm07MsgTid "SWTST_vu8Dm07MsgTid" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F94 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data "SWTST_vu8Dm30Data" UBYTE I_5 1 2 0 255 MATRIX_DIM 100 1 1 ECU_ADDRESS 0x60010F30 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[0] "SWTST_vu8Dm30Data[0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F30 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[10] "SWTST_vu8Dm30Data[10]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F3A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[11] "SWTST_vu8Dm30Data[11]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F3B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[12] "SWTST_vu8Dm30Data[12]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F3C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[13] "SWTST_vu8Dm30Data[13]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F3D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[14] "SWTST_vu8Dm30Data[14]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F3E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[15] "SWTST_vu8Dm30Data[15]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F3F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[16] "SWTST_vu8Dm30Data[16]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F40 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[17] "SWTST_vu8Dm30Data[17]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F41 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[18] "SWTST_vu8Dm30Data[18]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F42 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[19] "SWTST_vu8Dm30Data[19]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F43 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[1] "SWTST_vu8Dm30Data[1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F31 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[20] "SWTST_vu8Dm30Data[20]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F44 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[21] "SWTST_vu8Dm30Data[21]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F45 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[22] "SWTST_vu8Dm30Data[22]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F46 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[23] "SWTST_vu8Dm30Data[23]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F47 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[24] "SWTST_vu8Dm30Data[24]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F48 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[25] "SWTST_vu8Dm30Data[25]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F49 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[26] "SWTST_vu8Dm30Data[26]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F4A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[27] "SWTST_vu8Dm30Data[27]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F4B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[28] "SWTST_vu8Dm30Data[28]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F4C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[29] "SWTST_vu8Dm30Data[29]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F4D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[2] "SWTST_vu8Dm30Data[2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F32 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[30] "SWTST_vu8Dm30Data[30]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F4E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[31] "SWTST_vu8Dm30Data[31]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F4F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[32] "SWTST_vu8Dm30Data[32]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F50 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[33] "SWTST_vu8Dm30Data[33]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F51 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[34] "SWTST_vu8Dm30Data[34]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F52 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[35] "SWTST_vu8Dm30Data[35]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F53 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[36] "SWTST_vu8Dm30Data[36]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F54 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[37] "SWTST_vu8Dm30Data[37]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F55 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[38] "SWTST_vu8Dm30Data[38]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F56 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[39] "SWTST_vu8Dm30Data[39]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F57 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[3] "SWTST_vu8Dm30Data[3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F33 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[40] "SWTST_vu8Dm30Data[40]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F58 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[41] "SWTST_vu8Dm30Data[41]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F59 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[42] "SWTST_vu8Dm30Data[42]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F5A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[43] "SWTST_vu8Dm30Data[43]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F5B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[44] "SWTST_vu8Dm30Data[44]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F5C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[45] "SWTST_vu8Dm30Data[45]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F5D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[46] "SWTST_vu8Dm30Data[46]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F5E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[47] "SWTST_vu8Dm30Data[47]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F5F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[48] "SWTST_vu8Dm30Data[48]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F60 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[49] "SWTST_vu8Dm30Data[49]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F61 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[4] "SWTST_vu8Dm30Data[4]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F34 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[50] "SWTST_vu8Dm30Data[50]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F62 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[51] "SWTST_vu8Dm30Data[51]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F63 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[52] "SWTST_vu8Dm30Data[52]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F64 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[53] "SWTST_vu8Dm30Data[53]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F65 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[54] "SWTST_vu8Dm30Data[54]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F66 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[55] "SWTST_vu8Dm30Data[55]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F67 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[56] "SWTST_vu8Dm30Data[56]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F68 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[57] "SWTST_vu8Dm30Data[57]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F69 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[58] "SWTST_vu8Dm30Data[58]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F6A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[59] "SWTST_vu8Dm30Data[59]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F6B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[5] "SWTST_vu8Dm30Data[5]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F35 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[60] "SWTST_vu8Dm30Data[60]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F6C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[61] "SWTST_vu8Dm30Data[61]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F6D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[62] "SWTST_vu8Dm30Data[62]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F6E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[63] "SWTST_vu8Dm30Data[63]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F6F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[64] "SWTST_vu8Dm30Data[64]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F70 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[65] "SWTST_vu8Dm30Data[65]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F71 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[66] "SWTST_vu8Dm30Data[66]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F72 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[67] "SWTST_vu8Dm30Data[67]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F73 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[68] "SWTST_vu8Dm30Data[68]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F74 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[69] "SWTST_vu8Dm30Data[69]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F75 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[6] "SWTST_vu8Dm30Data[6]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F36 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[70] "SWTST_vu8Dm30Data[70]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F76 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[71] "SWTST_vu8Dm30Data[71]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F77 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[72] "SWTST_vu8Dm30Data[72]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F78 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[73] "SWTST_vu8Dm30Data[73]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F79 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[74] "SWTST_vu8Dm30Data[74]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F7A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[75] "SWTST_vu8Dm30Data[75]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F7B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[76] "SWTST_vu8Dm30Data[76]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F7C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[77] "SWTST_vu8Dm30Data[77]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F7D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[78] "SWTST_vu8Dm30Data[78]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F7E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[79] "SWTST_vu8Dm30Data[79]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F7F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[7] "SWTST_vu8Dm30Data[7]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F37 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[80] "SWTST_vu8Dm30Data[80]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F80 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[81] "SWTST_vu8Dm30Data[81]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F81 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[82] "SWTST_vu8Dm30Data[82]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F82 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[83] "SWTST_vu8Dm30Data[83]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F83 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[84] "SWTST_vu8Dm30Data[84]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F84 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[85] "SWTST_vu8Dm30Data[85]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F85 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[86] "SWTST_vu8Dm30Data[86]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F86 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[87] "SWTST_vu8Dm30Data[87]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F87 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[88] "SWTST_vu8Dm30Data[88]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F88 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[89] "SWTST_vu8Dm30Data[89]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F89 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[8] "SWTST_vu8Dm30Data[8]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F38 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[90] "SWTST_vu8Dm30Data[90]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F8A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[91] "SWTST_vu8Dm30Data[91]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F8B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[92] "SWTST_vu8Dm30Data[92]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F8C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[93] "SWTST_vu8Dm30Data[93]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F8D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[94] "SWTST_vu8Dm30Data[94]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F8E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[95] "SWTST_vu8Dm30Data[95]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F8F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[96] "SWTST_vu8Dm30Data[96]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F90 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[97] "SWTST_vu8Dm30Data[97]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F91 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[98] "SWTST_vu8Dm30Data[98]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F92 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[99] "SWTST_vu8Dm30Data[99]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F93 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30Data[9] "SWTST_vu8Dm30Data[9]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F39 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Dm30MsgLen "SWTST_vu8Dm30MsgLen" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F2F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8FimRunngTstNr "Current test running" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F2E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8LostCommFltTst "lost communication fault status" UBYTE I_5 1 2 0 255 MATRIX_DIM 8 1 1 ECU_ADDRESS 0x60010F26 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8LostCommFltTst[0] "SWTST_vu8LostCommFltTst[0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F26 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8LostCommFltTst[1] "SWTST_vu8LostCommFltTst[1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F27 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8LostCommFltTst[2] "SWTST_vu8LostCommFltTst[2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F28 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8LostCommFltTst[3] "SWTST_vu8LostCommFltTst[3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F29 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8LostCommFltTst[4] "SWTST_vu8LostCommFltTst[4]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F2A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8LostCommFltTst[5] "SWTST_vu8LostCommFltTst[5]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F2B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8LostCommFltTst[6] "SWTST_vu8LostCommFltTst[6]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F2C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8LostCommFltTst[7] "SWTST_vu8LostCommFltTst[7]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F2D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8SftyRunngTstNr "Current test running" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F25 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0OpenFltTst "solenoid short to battery status" UBYTE I_5 1 2 0 255 MATRIX_DIM 12 1 1 ECU_ADDRESS 0x60010F19 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0OpenFltTst[0] "SWTST_vu8TLE62X0OpenFltTst[0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F19 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0OpenFltTst[10] "SWTST_vu8TLE62X0OpenFltTst[10]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F23 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0OpenFltTst[11] "SWTST_vu8TLE62X0OpenFltTst[11]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F24 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0OpenFltTst[1] "SWTST_vu8TLE62X0OpenFltTst[1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F1A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0OpenFltTst[2] "SWTST_vu8TLE62X0OpenFltTst[2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F1B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0OpenFltTst[3] "SWTST_vu8TLE62X0OpenFltTst[3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F1C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0OpenFltTst[4] "SWTST_vu8TLE62X0OpenFltTst[4]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F1D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0OpenFltTst[5] "SWTST_vu8TLE62X0OpenFltTst[5]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F1E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0OpenFltTst[6] "SWTST_vu8TLE62X0OpenFltTst[6]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F1F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0OpenFltTst[7] "SWTST_vu8TLE62X0OpenFltTst[7]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F20 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0OpenFltTst[8] "SWTST_vu8TLE62X0OpenFltTst[8]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F21 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0OpenFltTst[9] "SWTST_vu8TLE62X0OpenFltTst[9]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F22 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0ScFltTst "solenoid short to ground status" UBYTE I_5 1 2 0 255 MATRIX_DIM 12 1 1 ECU_ADDRESS 0x60010F0C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0ScFltTst[0] "SWTST_vu8TLE62X0ScFltTst[0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F0C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0ScFltTst[10] "SWTST_vu8TLE62X0ScFltTst[10]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F16 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0ScFltTst[11] "SWTST_vu8TLE62X0ScFltTst[11]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F17 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0ScFltTst[1] "SWTST_vu8TLE62X0ScFltTst[1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F0D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0ScFltTst[2] "SWTST_vu8TLE62X0ScFltTst[2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F0E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0ScFltTst[3] "SWTST_vu8TLE62X0ScFltTst[3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F0F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0ScFltTst[4] "SWTST_vu8TLE62X0ScFltTst[4]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F10 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0ScFltTst[5] "SWTST_vu8TLE62X0ScFltTst[5]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F11 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0ScFltTst[6] "SWTST_vu8TLE62X0ScFltTst[6]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F12 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0ScFltTst[7] "SWTST_vu8TLE62X0ScFltTst[7]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F13 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0ScFltTst[8] "SWTST_vu8TLE62X0ScFltTst[8]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F14 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0ScFltTst[9] "SWTST_vu8TLE62X0ScFltTst[9]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F15 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0ScsFltTst "solenoid short to battery status" UBYTE I_5 1 2 0 255 MATRIX_DIM 12 1 1 ECU_ADDRESS 0x60010F00 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0ScsFltTst[0] "SWTST_vu8TLE62X0ScsFltTst[0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F00 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0ScsFltTst[10] "SWTST_vu8TLE62X0ScsFltTst[10]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F0A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0ScsFltTst[11] "SWTST_vu8TLE62X0ScsFltTst[11]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F0B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0ScsFltTst[1] "SWTST_vu8TLE62X0ScsFltTst[1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F01 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0ScsFltTst[2] "SWTST_vu8TLE62X0ScsFltTst[2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F02 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0ScsFltTst[3] "SWTST_vu8TLE62X0ScsFltTst[3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F03 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0ScsFltTst[4] "SWTST_vu8TLE62X0ScsFltTst[4]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F04 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0ScsFltTst[5] "SWTST_vu8TLE62X0ScsFltTst[5]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F05 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0ScsFltTst[6] "SWTST_vu8TLE62X0ScsFltTst[6]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F06 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0ScsFltTst[7] "SWTST_vu8TLE62X0ScsFltTst[7]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F07 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0ScsFltTst[8] "SWTST_vu8TLE62X0ScsFltTst[8]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F08 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TLE62X0ScsFltTst[9] "SWTST_vu8TLE62X0ScsFltTst[9]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F09 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Tle62X0RunngTstNr "Current test running" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010F18 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8Tle8242RunngTstNr "Current test running" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EFF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8TrimRunngTstNr "Current test running" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EFE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT SWTST_vu8WdgRunngTstNr "Current test running" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EFD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_af32TarCnrtMa "TSTDV_af32TarCnrtMa" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 MATRIX_DIM 15 1 1 ECU_ADDRESS 0x60014AB0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_af32TarCnrtMa[0] "TSTDV_af32TarCnrtMa[0]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014AB0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_af32TarCnrtMa[10] "TSTDV_af32TarCnrtMa[10]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014AD8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_af32TarCnrtMa[11] "TSTDV_af32TarCnrtMa[11]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014ADC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_af32TarCnrtMa[12] "TSTDV_af32TarCnrtMa[12]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014AE0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_af32TarCnrtMa[13] "TSTDV_af32TarCnrtMa[13]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014AE4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_af32TarCnrtMa[14] "TSTDV_af32TarCnrtMa[14]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014AE8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_af32TarCnrtMa[1] "TSTDV_af32TarCnrtMa[1]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014AB4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_af32TarCnrtMa[2] "TSTDV_af32TarCnrtMa[2]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014AB8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_af32TarCnrtMa[3] "TSTDV_af32TarCnrtMa[3]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014ABC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_af32TarCnrtMa[4] "TSTDV_af32TarCnrtMa[4]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014AC0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_af32TarCnrtMa[5] "TSTDV_af32TarCnrtMa[5]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014AC4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_af32TarCnrtMa[6] "TSTDV_af32TarCnrtMa[6]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014AC8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_af32TarCnrtMa[7] "TSTDV_af32TarCnrtMa[7]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014ACC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_af32TarCnrtMa[8] "TSTDV_af32TarCnrtMa[8]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014AD0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_af32TarCnrtMa[9] "TSTDV_af32TarCnrtMa[9]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014AD4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8CmnHSDTstEna "TSTDV_au8CmnHSDTstEna" UBYTE I_5 1 2 0 255 MATRIX_DIM 4 1 1 ECU_ADDRESS 0x60010EF6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8CmnHSDTstEna[0] "TSTDV_au8CmnHSDTstEna[0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EF6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8CmnHSDTstEna[1] "TSTDV_au8CmnHSDTstEna[1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EF7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8CmnHSDTstEna[2] "TSTDV_au8CmnHSDTstEna[2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EF8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8CmnHSDTstEna[3] "TSTDV_au8CmnHSDTstEna[3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EF9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8CmnLSDTstEna "TSTDV_au8CmnLSDTstEna" UBYTE I_5 1 2 0 255 MATRIX_DIM 12 1 1 ECU_ADDRESS 0x60010EEA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8CmnLSDTstEna[0] "TSTDV_au8CmnLSDTstEna[0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EEA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8CmnLSDTstEna[10] "TSTDV_au8CmnLSDTstEna[10]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EF4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8CmnLSDTstEna[11] "TSTDV_au8CmnLSDTstEna[11]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EF5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8CmnLSDTstEna[1] "TSTDV_au8CmnLSDTstEna[1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EEB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8CmnLSDTstEna[2] "TSTDV_au8CmnLSDTstEna[2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EEC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8CmnLSDTstEna[3] "TSTDV_au8CmnLSDTstEna[3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EED READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8CmnLSDTstEna[4] "TSTDV_au8CmnLSDTstEna[4]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EEE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8CmnLSDTstEna[5] "TSTDV_au8CmnLSDTstEna[5]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EEF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8CmnLSDTstEna[6] "TSTDV_au8CmnLSDTstEna[6]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EF0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8CmnLSDTstEna[7] "TSTDV_au8CmnLSDTstEna[7]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EF1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8CmnLSDTstEna[8] "TSTDV_au8CmnLSDTstEna[8]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EF2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8CmnLSDTstEna[9] "TSTDV_au8CmnLSDTstEna[9]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EF3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8SoleHSDTstEna "TSTDV_au8SoleHSDTstEna" UBYTE I_5 1 2 0 255 MATRIX_DIM 4 1 1 ECU_ADDRESS 0x60010EE6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8SoleHSDTstEna[0] "TSTDV_au8SoleHSDTstEna[0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EE6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8SoleHSDTstEna[1] "TSTDV_au8SoleHSDTstEna[1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EE7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8SoleHSDTstEna[2] "TSTDV_au8SoleHSDTstEna[2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EE8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8SoleHSDTstEna[3] "TSTDV_au8SoleHSDTstEna[3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EE9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8SoleTstEna "TSTDV_au8SoleTstEna" UBYTE I_5 1 2 0 255 MATRIX_DIM 15 1 1 ECU_ADDRESS 0x60010ED7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8SoleTstEna[0] "TSTDV_au8SoleTstEna[0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010ED7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8SoleTstEna[10] "TSTDV_au8SoleTstEna[10]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EE1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8SoleTstEna[11] "TSTDV_au8SoleTstEna[11]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EE2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8SoleTstEna[12] "TSTDV_au8SoleTstEna[12]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EE3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8SoleTstEna[13] "TSTDV_au8SoleTstEna[13]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EE4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8SoleTstEna[14] "TSTDV_au8SoleTstEna[14]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EE5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8SoleTstEna[1] "TSTDV_au8SoleTstEna[1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010ED8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8SoleTstEna[2] "TSTDV_au8SoleTstEna[2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010ED9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8SoleTstEna[3] "TSTDV_au8SoleTstEna[3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EDA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8SoleTstEna[4] "TSTDV_au8SoleTstEna[4]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EDB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8SoleTstEna[5] "TSTDV_au8SoleTstEna[5]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EDC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8SoleTstEna[6] "TSTDV_au8SoleTstEna[6]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EDD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8SoleTstEna[7] "TSTDV_au8SoleTstEna[7]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EDE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8SoleTstEna[8] "TSTDV_au8SoleTstEna[8]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EDF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_au8SoleTstEna[9] "TSTDV_au8SoleTstEna[9]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EE0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_u8TstCurIdx "TSTDV_u8TstCurIdx" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010ED6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_u8TstIdx "TSTDV_u8TstIdx" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010ED5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_u8TstIdxChgReq "TSTDV_u8TstIdxChgReq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010ED4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_u8TstIdxReq "TSTDV_u8TstIdxReq" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010ED3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_u8TstSubIdx "TSTDV_u8TstSubIdx" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010ED2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_vu16SpdoDuty "TSTDV_vu16SpdoDuty" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60010DDC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TSTDV_vu32SpdoFrq "TSTDV_vu32SpdoFrq" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600128B0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWD_u32EngSpdHallPwmTon "TST_PWD_u32EngSpdHallPwmTon" ULONG F_1_p0_36 1 2 0 4294967295 ECU_ADDRESS 0x600128E8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWD_u32InpSpdHallPwmTon "TST_PWD_u32InpSpdHallPwmTon" ULONG F_1_p0_36 1 2 0 4294967295 ECU_ADDRESS 0x600128E4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWD_u32OutpSpdHallPwmTon "TST_PWD_u32OutpSpdHallPwmTon" ULONG F_1_p0_36 1 2 0 4294967295 ECU_ADDRESS 0x600128E0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWD_u32_ENG_SPD_HALL_PWM_DUTYCYC "TST_PWD_u32_ENG_SPD_HALL_PWM_DUTYCYC" ULONG F_0v0061035156_p0_26 1 2 0 26214399.99 ECU_ADDRESS 0x60012930 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWD_u32_ENG_SPD_HALL_PWM_FRQ "TST_PWD_u32_ENG_SPD_HALL_PWM_FRQ" ULONG F_1_p0_37 1 2 0 4294967295 ECU_ADDRESS 0x6001292C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWD_u32_ENG_SPD_VR_PWM_DUTYCYC "TST_PWD_u32_ENG_SPD_VR_PWM_DUTYCYC" ULONG F_0v0061035156_p0_26 1 2 0 26214399.99 ECU_ADDRESS 0x60012928 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWD_u32_ENG_SPD_VR_PWM_FRQ "TST_PWD_u32_ENG_SPD_VR_PWM_FRQ" ULONG F_1_p0_37 1 2 0 4294967295 ECU_ADDRESS 0x60012924 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWD_u32_INPUT_SPD_HALL_PWM_DUTYCYC "TST_PWD_u32_INPUT_SPD_HALL_PWM_DUTYCYC" ULONG F_0v0061035156_p0_26 1 2 0 26214399.99 ECU_ADDRESS 0x60012920 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWD_u32_INPUT_SPD_HALL_PWM_FRQ "TST_PWD_u32_INPUT_SPD_HALL_PWM_FRQ" ULONG F_1_p0_37 1 2 0 4294967295 ECU_ADDRESS 0x6001291C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWD_u32_INPUT_SPD_VR_PWM_DUTYCYC "TST_PWD_u32_INPUT_SPD_VR_PWM_DUTYCYC" ULONG F_0v0061035156_p0_26 1 2 0 26214399.99 ECU_ADDRESS 0x60012918 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWD_u32_INPUT_SPD_VR_PWM_FRQ "TST_PWD_u32_INPUT_SPD_VR_PWM_FRQ" ULONG F_1_p0_37 1 2 0 4294967295 ECU_ADDRESS 0x60012914 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWD_u32_OUTPUT_SPD_HALL_PWM_DUTYCYC "TST_PWD_u32_OUTPUT_SPD_HALL_PWM_DUTYCYC" ULONG F_0v0061035156_p0_26 1 2 0 26214399.99 ECU_ADDRESS 0x60012910 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWD_u32_OUTPUT_SPD_HALL_PWM_FRQ "TST_PWD_u32_OUTPUT_SPD_HALL_PWM_FRQ" ULONG F_1_p0_37 1 2 0 4294967295 ECU_ADDRESS 0x6001290C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWD_u32_OUTPUT_SPD_VR_PWM_DUTYCYC "TST_PWD_u32_OUTPUT_SPD_VR_PWM_DUTYCYC" ULONG F_0v0061035156_p0_26 1 2 0 26214399.99 ECU_ADDRESS 0x60012908 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWD_u32_OUTPUT_SPD_VR_PWM_FRQ "TST_PWD_u32_OUTPUT_SPD_VR_PWM_FRQ" ULONG F_1_p0_37 1 2 0 4294967295 ECU_ADDRESS 0x60012904 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWD_u32_PWM_IN_1_DUTYCYC "TST_PWD_u32_PWM_IN_1_DUTYCYC" ULONG F_0v0061035156_p0_26 1 2 0 26214399.99 ECU_ADDRESS 0x60012900 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWD_u32_PWM_IN_1_FRQ "TST_PWD_u32_PWM_IN_1_FRQ" ULONG F_1_p0_37 1 2 0 4294967295 ECU_ADDRESS 0x600128FC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWD_u32_PWM_IN_2_DUTYCYC "TST_PWD_u32_PWM_IN_2_DUTYCYC" ULONG F_0v0061035156_p0_26 1 2 0 26214399.99 ECU_ADDRESS 0x600128F8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWD_u32_PWM_IN_2_FRQ "TST_PWD_u32_PWM_IN_2_FRQ" ULONG F_1_p0_37 1 2 0 4294967295 ECU_ADDRESS 0x600128F4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWD_u32_PWM_IN_3_DUTYCYC "TST_PWD_u32_PWM_IN_3_DUTYCYC" ULONG F_0v0061035156_p0_26 1 2 0 26214399.99 ECU_ADDRESS 0x600128F0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWD_u32_PWM_IN_3_FRQ "TST_PWD_u32_PWM_IN_3_FRQ" ULONG F_1_p0_37 1 2 0 4294967295 ECU_ADDRESS 0x600128EC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWM_bPWM_ENA_AUXILIARIES_ON_OFF_VALVE "TST_PWM_bPWM_ENA_AUXILIARIES_ON_OFF_VALVE" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A50 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWM_bPWM_ENA_DUAL_AREA_PISTON_SOLENOID "TST_PWM_bPWM_ENA_DUAL_AREA_PISTON_SOLENOID" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A4F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWM_bPWM_ENA_LIMP_HOME_SAFE "TST_PWM_bPWM_ENA_LIMP_HOME_SAFE" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A4E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWM_bPWM_ENA_RETARDER_ACCUMULATOR "TST_PWM_bPWM_ENA_RETARDER_ACCUMULATOR" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A4D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWM_bPWM_ENA_SEL_COOLING "TST_PWM_bPWM_ENA_SEL_COOLING" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60014A4C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWM_f32PWM_FRQ_AUXILIARIES_ON_OFF_VALVE "TST_PWM_f32PWM_FRQ_AUXILIARIES_ON_OFF_VALVE" FLOAT32_IEEE F_1_p0_38 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C68 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWM_f32PWM_FRQ_DUAL_AREA_PISTON_SOLENOID "TST_PWM_f32PWM_FRQ_DUAL_AREA_PISTON_SOLENOID" FLOAT32_IEEE F_1_p0_38 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C64 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWM_f32PWM_FRQ_LIMP_HOME_SAFE "TST_PWM_f32PWM_FRQ_LIMP_HOME_SAFE" FLOAT32_IEEE F_1_p0_38 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C60 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWM_f32PWM_FRQ_RETARDER_ACCUMULATOR "TST_PWM_f32PWM_FRQ_RETARDER_ACCUMULATOR" FLOAT32_IEEE F_1_p0_38 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C5C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWM_f32PWM_FRQ_SEL_COOLING "TST_PWM_f32PWM_FRQ_SEL_COOLING" FLOAT32_IEEE F_1_p0_38 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C58 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWM_s16PCS_AUX_DUTYCYC "TST_PWM_s16PCS_AUX_DUTYCYC" SWORD F_0v0061035156_p0_26 1 2 -200 199.9938965 ECU_ADDRESS 0x60010E8C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWM_s16PCS_B1_DUTYCYC "TST_PWM_s16PCS_B1_DUTYCYC" SWORD F_0v0061035156_p0_26 1 2 -200 199.9938965 ECU_ADDRESS 0x60010E8A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWM_s16PCS_B2_DUTYCYC "TST_PWM_s16PCS_B2_DUTYCYC" SWORD F_0v0061035156_p0_26 1 2 -200 199.9938965 ECU_ADDRESS 0x60010E88 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWM_s16PCS_B3_DUTYCYC "TST_PWM_s16PCS_B3_DUTYCYC" SWORD F_0v0061035156_p0_26 1 2 -200 199.9938965 ECU_ADDRESS 0x60010E86 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWM_s16PCS_B4_DUTYCYC "TST_PWM_s16PCS_B4_DUTYCYC" SWORD F_0v0061035156_p0_26 1 2 -200 199.9938965 ECU_ADDRESS 0x60010E84 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWM_s16PCS_C1_DUTYCYC "TST_PWM_s16PCS_C1_DUTYCYC" SWORD F_0v0061035156_p0_26 1 2 -200 199.9938965 ECU_ADDRESS 0x60010E82 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWM_s16PCS_C2_DUTYCYC "TST_PWM_s16PCS_C2_DUTYCYC" SWORD F_0v0061035156_p0_26 1 2 -200 199.9938965 ECU_ADDRESS 0x60010E80 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWM_s16PCS_LUC_DUTYCYC "TST_PWM_s16PCS_LUC_DUTYCYC" SWORD F_0v0061035156_p0_26 1 2 -200 199.9938965 ECU_ADDRESS 0x60010E7E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWM_s16PCS_MLP_DUTYCYC "TST_PWM_s16PCS_MLP_DUTYCYC" SWORD F_0v0061035156_p0_26 1 2 -200 199.9938965 ECU_ADDRESS 0x60010E7C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWM_s16PCS_RET_DUTYCYC "TST_PWM_s16PCS_RET_DUTYCYC" SWORD F_0v0061035156_p0_26 1 2 -200 199.9938965 ECU_ADDRESS 0x60010E7A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWM_s16PWM_DUTY_AUXILIARIES_ON_OFF_VALVE "TST_PWM_s16PWM_DUTY_AUXILIARIES_ON_OFF_VALVE" SWORD F_0v0061035156_p0_26 1 2 -200 199.9938965 ECU_ADDRESS 0x60010E78 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWM_s16PWM_DUTY_DUAL_AREA_PISTON_SOLENOID "TST_PWM_s16PWM_DUTY_DUAL_AREA_PISTON_SOLENOID" SWORD F_0v0061035156_p0_26 1 2 -200 199.9938965 ECU_ADDRESS 0x60010E76 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWM_s16PWM_DUTY_LIMP_HOME_SAFE "TST_PWM_s16PWM_DUTY_LIMP_HOME_SAFE" SWORD F_0v0061035156_p0_26 1 2 -200 199.9938965 ECU_ADDRESS 0x60010E74 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWM_s16PWM_DUTY_RETARDER_ACCUMULATOR "TST_PWM_s16PWM_DUTY_RETARDER_ACCUMULATOR" SWORD F_0v0061035156_p0_26 1 2 -200 199.9938965 ECU_ADDRESS 0x60010E72 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWM_s16PWM_DUTY_SEL_COOLING "TST_PWM_s16PWM_DUTY_SEL_COOLING" SWORD F_0v0061035156_p0_26 1 2 -200 199.9938965 ECU_ADDRESS 0x60010E70 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWM_u32PCS_G1_FRQ "TST_PWM_u32PCS_G1_FRQ" ULONG F_1_p0_37 1 2 0 4294967295 ECU_ADDRESS 0x600128DC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWM_u32PCS_G2_FRQ "TST_PWM_u32PCS_G2_FRQ" ULONG F_1_p0_37 1 2 0 4294967295 ECU_ADDRESS 0x600128D8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWM_u32PCS_G3_FRQ "TST_PWM_u32PCS_G3_FRQ" ULONG F_1_p0_37 1 2 0 4294967295 ECU_ADDRESS 0x600128D4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_PWM_u32PCS_G4_FRQ "TST_PWM_u32PCS_G4_FRQ" ULONG F_1_p0_37 1 2 0 4294967295 ECU_ADDRESS 0x600128D0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_StackMeas_au32MaxUsg "TST_StackMeas_au32MaxUsg" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 3 1 1 ECU_ADDRESS 0x600128C4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_StackMeas_au32MaxUsg[0] "TST_StackMeas_au32MaxUsg[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600128C4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_StackMeas_au32MaxUsg[1] "TST_StackMeas_au32MaxUsg[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600128C8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_StackMeas_au32MaxUsg[2] "TST_StackMeas_au32MaxUsg[2]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600128CC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_StackMeas_au32StackSize "TST_StackMeas_au32StackSize" ULONG I_5 1 2 0 4294967295 MATRIX_DIM 3 1 1 ECU_ADDRESS 0x600128B8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_StackMeas_au32StackSize[0] "TST_StackMeas_au32StackSize[0]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600128B8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_StackMeas_au32StackSize[1] "TST_StackMeas_au32StackSize[1]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600128BC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_StackMeas_au32StackSize[2] "TST_StackMeas_au32StackSize[2]" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600128C0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_StackMeas_u32RdOutofRng "TST_StackMeas_u32RdOutofRng" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600128B4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_StackMeas_u8TstCaseSel "TST_StackMeas_u8TstCaseSel" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EFC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32Gt2 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 MATRIX_DIM 15 1 1 ECU_ADDRESS 0x60014BA4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32Gt2[0] "TST_TRIM_af32Gt2[0]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014BA4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32Gt2[10] "TST_TRIM_af32Gt2[10]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014BCC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32Gt2[11] "TST_TRIM_af32Gt2[11]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014BD0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32Gt2[12] "TST_TRIM_af32Gt2[12]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014BD4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32Gt2[13] "TST_TRIM_af32Gt2[13]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014BD8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32Gt2[14] "TST_TRIM_af32Gt2[14]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014BDC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32Gt2[1] "TST_TRIM_af32Gt2[1]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014BA8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32Gt2[2] "TST_TRIM_af32Gt2[2]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014BAC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32Gt2[3] "TST_TRIM_af32Gt2[3]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014BB0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32Gt2[4] "TST_TRIM_af32Gt2[4]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014BB4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32Gt2[5] "TST_TRIM_af32Gt2[5]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014BB8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32Gt2[6] "TST_TRIM_af32Gt2[6]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014BBC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32Gt2[7] "TST_TRIM_af32Gt2[7]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014BC0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32Gt2[8] "TST_TRIM_af32Gt2[8]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014BC4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32Gt2[9] "TST_TRIM_af32Gt2[9]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014BC8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32Ot2 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 MATRIX_DIM 15 1 1 ECU_ADDRESS 0x60014AF0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32Ot2[0] "TST_TRIM_af32Ot2[0]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014AF0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32Ot2[10] "TST_TRIM_af32Ot2[10]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B18 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32Ot2[11] "TST_TRIM_af32Ot2[11]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B1C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32Ot2[12] "TST_TRIM_af32Ot2[12]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B20 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32Ot2[13] "TST_TRIM_af32Ot2[13]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B24 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32Ot2[14] "TST_TRIM_af32Ot2[14]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B28 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32Ot2[1] "TST_TRIM_af32Ot2[1]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014AF4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32Ot2[2] "TST_TRIM_af32Ot2[2]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014AF8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32Ot2[3] "TST_TRIM_af32Ot2[3]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014AFC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32Ot2[4] "TST_TRIM_af32Ot2[4]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B00 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32Ot2[5] "TST_TRIM_af32Ot2[5]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B04 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32Ot2[6] "TST_TRIM_af32Ot2[6]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B08 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32Ot2[7] "TST_TRIM_af32Ot2[7]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B0C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32Ot2[8] "TST_TRIM_af32Ot2[8]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B10 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32Ot2[9] "TST_TRIM_af32Ot2[9]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B14 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32g_G "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 MATRIX_DIM 15 1 1 ECU_ADDRESS 0x60014C1C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32g_G[0] "TST_TRIM_af32g_G[0]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C1C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32g_G[10] "TST_TRIM_af32g_G[10]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C44 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32g_G[11] "TST_TRIM_af32g_G[11]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C48 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32g_G[12] "TST_TRIM_af32g_G[12]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C4C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32g_G[13] "TST_TRIM_af32g_G[13]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C50 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32g_G[14] "TST_TRIM_af32g_G[14]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C54 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32g_G[1] "TST_TRIM_af32g_G[1]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C20 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32g_G[2] "TST_TRIM_af32g_G[2]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C24 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32g_G[3] "TST_TRIM_af32g_G[3]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C28 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32g_G[4] "TST_TRIM_af32g_G[4]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C2C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32g_G[5] "TST_TRIM_af32g_G[5]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C30 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32g_G[6] "TST_TRIM_af32g_G[6]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C34 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32g_G[7] "TST_TRIM_af32g_G[7]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C38 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32g_G[8] "TST_TRIM_af32g_G[8]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C3C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32g_G[9] "TST_TRIM_af32g_G[9]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C40 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32g_O "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 MATRIX_DIM 15 1 1 ECU_ADDRESS 0x60014BE0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32g_O[0] "TST_TRIM_af32g_O[0]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014BE0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32g_O[10] "TST_TRIM_af32g_O[10]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C08 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32g_O[11] "TST_TRIM_af32g_O[11]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C0C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32g_O[12] "TST_TRIM_af32g_O[12]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C10 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32g_O[13] "TST_TRIM_af32g_O[13]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C14 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32g_O[14] "TST_TRIM_af32g_O[14]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C18 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32g_O[1] "TST_TRIM_af32g_O[1]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014BE4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32g_O[2] "TST_TRIM_af32g_O[2]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014BE8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32g_O[3] "TST_TRIM_af32g_O[3]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014BEC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32g_O[4] "TST_TRIM_af32g_O[4]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014BF0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32g_O[5] "TST_TRIM_af32g_O[5]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014BF4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32g_O[6] "TST_TRIM_af32g_O[6]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014BF8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32g_O[7] "TST_TRIM_af32g_O[7]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014BFC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32g_O[8] "TST_TRIM_af32g_O[8]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C00 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32g_O[9] "TST_TRIM_af32g_O[9]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014C04 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32o_G "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 MATRIX_DIM 15 1 1 ECU_ADDRESS 0x60014B68 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32o_G[0] "TST_TRIM_af32o_G[0]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B68 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32o_G[10] "TST_TRIM_af32o_G[10]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B90 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32o_G[11] "TST_TRIM_af32o_G[11]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B94 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32o_G[12] "TST_TRIM_af32o_G[12]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B98 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32o_G[13] "TST_TRIM_af32o_G[13]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B9C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32o_G[14] "TST_TRIM_af32o_G[14]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014BA0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32o_G[1] "TST_TRIM_af32o_G[1]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B6C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32o_G[2] "TST_TRIM_af32o_G[2]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B70 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32o_G[3] "TST_TRIM_af32o_G[3]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B74 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32o_G[4] "TST_TRIM_af32o_G[4]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B78 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32o_G[5] "TST_TRIM_af32o_G[5]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B7C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32o_G[6] "TST_TRIM_af32o_G[6]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B80 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32o_G[7] "TST_TRIM_af32o_G[7]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B84 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32o_G[8] "TST_TRIM_af32o_G[8]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B88 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32o_G[9] "TST_TRIM_af32o_G[9]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B8C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32o_O "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 MATRIX_DIM 15 1 1 ECU_ADDRESS 0x60014B2C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32o_O[0] "TST_TRIM_af32o_O[0]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B2C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32o_O[10] "TST_TRIM_af32o_O[10]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B54 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32o_O[11] "TST_TRIM_af32o_O[11]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B58 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32o_O[12] "TST_TRIM_af32o_O[12]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B5C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32o_O[13] "TST_TRIM_af32o_O[13]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B60 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32o_O[14] "TST_TRIM_af32o_O[14]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B64 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32o_O[1] "TST_TRIM_af32o_O[1]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B30 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32o_O[2] "TST_TRIM_af32o_O[2]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B34 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32o_O[3] "TST_TRIM_af32o_O[3]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B38 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32o_O[4] "TST_TRIM_af32o_O[4]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B3C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32o_O[5] "TST_TRIM_af32o_O[5]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B40 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32o_O[6] "TST_TRIM_af32o_O[6]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B44 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32o_O[7] "TST_TRIM_af32o_O[7]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B48 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32o_O[8] "TST_TRIM_af32o_O[8]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B4C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_af32o_O[9] "TST_TRIM_af32o_O[9]" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014B50 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_f32T2 "value" FLOAT32_IEEE I_5 1 2 -3.402823466E+038 3.402823466E+038 ECU_ADDRESS 0x60014AEC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_TRIM_u8TstMod "trim test mode" UBYTE I_39 1 2 0 255 ECU_ADDRESS 0x60010EFB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_u8OpCycleChangeFlagCCP "TST_u8OpCycleChangeFlagCCP" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60010EFA READ_WRITE /end MEASUREMENT
/begin COMPU_METHOD I_5 "" RAT_FUNC "%9.2" "-" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD F_0v0061035156_p0_26 "" RAT_FUNC "%9.3" "%" COEFFS 0 1 0 0 0 0.00610352 /end COMPU_METHOD
/begin COMPU_METHOD F_0v01_p0_27 "" RAT_FUNC "%9.2" "es" COEFFS 0 1 0 0 0 0.01 /end COMPU_METHOD
/begin COMPU_METHOD F_1_p1_28 "" RAT_FUNC "%9.2" "mA" COEFFS 0 1 -1 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD F_1_p1_29 "" RAT_FUNC "%9.2" "Hz" COEFFS 0 1 -1 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD F_1_p0_36 "" RAT_FUNC "%9.2" "us" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD F_1_p0_37 "" RAT_FUNC "%9.2" "Hz" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD F_1_p0_38 "" RAT_FUNC "%9.2" "kHz" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD I_39 "" RAT_FUNC "%9.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Id_0x00 "" RAT_FUNC "%9.2" "." COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Bool_ON_OFF "" TAB_VERB "%8.4" "." COMPU_TAB_REF Bool_ON_OFF_table /end COMPU_METHOD
/begin COMPU_VTAB Bool_ON_OFF_table "" TAB_VERB 2 0 "OFF" 1 "ON" /end COMPU_VTAB
/begin FUNCTION SWTST "" FUNCTION_VERSION "NONE_"
 /begin DEF_CHARACTERISTIC SWTST_aku16Duty SWTST_aku32Prd SWTST_f32TLE8242_LINEAR_VALVE_1_1_CrntTar SWTST_f32TLE8242_LINEAR_VALVE_1_1_DitherAmp SWTST_f32TLE8242_LINEAR_VALVE_1_1_DitherFrq SWTST_f32TLE8242_LINEAR_VALVE_1_1_PwmDuty SWTST_f32TLE8242_LINEAR_VALVE_1_2_CrntTar SWTST_f32TLE8242_LINEAR_VALVE_1_2_DitherAmp SWTST_f32TLE8242_LINEAR_VALVE_1_2_DitherFrq SWTST_f32TLE8242_LINEAR_VALVE_1_2_PwmDuty SWTST_f32TLE8242_LINEAR_VALVE_2_3_CrntTar SWTST_f32TLE8242_LINEAR_VALVE_2_3_DitherAmp SWTST_f32TLE8242_LINEAR_VALVE_2_3_DitherFrq SWTST_f32TLE8242_LINEAR_VALVE_2_3_PwmDuty SWTST_f32TLE8242_LINEAR_VALVE_2_4_CrntTar SWTST_f32TLE8242_LINEAR_VALVE_2_4_DitherAmp SWTST_f32TLE8242_LINEAR_VALVE_2_4_DitherFrq SWTST_f32TLE8242_LINEAR_VALVE_2_4_PwmDuty SWTST_f32TLE8242_LINEAR_VALVE_2_5_CrntTar SWTST_f32TLE8242_LINEAR_VALVE_2_5_DitherAmp SWTST_f32TLE8242_LINEAR_VALVE_2_5_DitherFrq SWTST_f32TLE8242_LINEAR_VALVE_2_5_PwmDuty SWTST_f32TLE8242_LINEAR_VALVE_3_6_CrntTar SWTST_f32TLE8242_LINEAR_VALVE_3_6_DitherAmp SWTST_f32TLE8242_LINEAR_VALVE_3_6_DitherFrq SWTST_f32TLE8242_LINEAR_VALVE_3_6_PwmDuty SWTST_f32TLE8242_LINEAR_VALVE_3_7_CrntTar SWTST_f32TLE8242_LINEAR_VALVE_3_7_DitherAmp SWTST_f32TLE8242_LINEAR_VALVE_3_7_DitherFrq SWTST_f32TLE8242_LINEAR_VALVE_3_7_PwmDuty SWTST_f32TLE8242_LINEAR_VALVE_3_8_CrntTar SWTST_f32TLE8242_LINEAR_VALVE_3_8_DitherAmp SWTST_f32TLE8242_LINEAR_VALVE_3_8_DitherFrq SWTST_f32TLE8242_LINEAR_VALVE_3_8_PwmDuty SWTST_f32TLE8242_LINEAR_VALVE_4_10_CrntTar SWTST_f32TLE8242_LINEAR_VALVE_4_10_DitherAmp SWTST_f32TLE8242_LINEAR_VALVE_4_10_DitherFrq SWTST_f32TLE8242_LINEAR_VALVE_4_10_PwmDuty SWTST_f32TLE8242_LINEAR_VALVE_4_9_CrntTar SWTST_f32TLE8242_LINEAR_VALVE_4_9_DitherAmp SWTST_f32TLE8242_LINEAR_VALVE_4_9_DitherFrq SWTST_f32TLE8242_LINEAR_VALVE_4_9_PwmDuty SWTST_f32TLE8242_PWM_VALVE_1_1_CrntTar SWTST_f32TLE8242_PWM_VALVE_1_1_DitherAmp SWTST_f32TLE8242_PWM_VALVE_1_1_DitherFrq SWTST_f32TLE8242_PWM_VALVE_1_1_PwmDuty SWTST_f32TLE8242_PWM_VALVE_1_2_CrntTar SWTST_f32TLE8242_PWM_VALVE_1_2_DitherAmp SWTST_f32TLE8242_PWM_VALVE_1_2_DitherFrq SWTST_f32TLE8242_PWM_VALVE_1_2_PwmDuty SWTST_f32TLE8242_PWM_VALVE_1_3_CrntTar SWTST_f32TLE8242_PWM_VALVE_1_3_DitherAmp SWTST_f32TLE8242_PWM_VALVE_1_3_DitherFrq SWTST_f32TLE8242_PWM_VALVE_1_3_PwmDuty SWTST_f32TLE8242_PWM_VALVE_4_4_CrntTar SWTST_f32TLE8242_PWM_VALVE_4_4_DitherAmp SWTST_f32TLE8242_PWM_VALVE_4_4_DitherFrq SWTST_f32TLE8242_PWM_VALVE_4_4_PwmDuty SWTST_f32TLE8242_PWM_VALVE_4_5_CrntTar SWTST_f32TLE8242_PWM_VALVE_4_5_DitherAmp SWTST_f32TLE8242_PWM_VALVE_4_5_DitherFrq SWTST_f32TLE8242_PWM_VALVE_4_5_PwmDuty SWTST_kau8FimDemEveStsCmd SWTST_kbAdcTstEnaC SWTST_kbBtt6020TstEnaC SWTST_kbCalibTstEnaC SWTST_kbComTstEnaC SWTST_kbDiagcTstEnaC SWTST_kbDioTstEnaC SWTST_kbDioWrBtt6030Den1 SWTST_kbDioWrBtt6030Den2 SWTST_kbDioWrBtt6030Dsel1 SWTST_kbDioWrBtt6030Dsel2 SWTST_kbDioWrDselCtrl SWTST_kbDioWrMaxShdn SWTST_kbDioWrOutHsd1Cmd SWTST_kbDioWrOutHsd2Cmd SWTST_kbDioWrOutHsd3Cmd SWTST_kbDioWrOutHsd4Cmd SWTST_kbDioWrP9vSnsSup1En SWTST_kbDioWrP9vSnsSup21En SWTST_kbDioWrP9vSnsSup22En SWTST_kbDioWrPowerDownEna SWTST_kbDioWrSolenoidHsCmd1 /end DEF_CHARACTERISTIC
 /begin OUT_MEASUREMENT SWTST_udtDcmCallBackDidRdCond0102 SWTST_udtDcmCallBackDidRdCond0103 SWTST_udtDcmCallBackDidRdCond0104 SWTST_udtDcmCallBackDidRdCond0105 SWTST_udtDcmCallBackDidRdCond0106 SWTST_udtDcmCallBackDidRdCond0107 SWTST_udtDcmCallBackDidRdCond0108 SWTST_udtDcmCallBackDidRdCond0109 SWTST_udtDcmCallBackDidRdCond010A SWTST_udtDcmCallBackDidRdCond010B SWTST_udtDcmCallBackDidRdCond010C SWTST_udtDcmCallBackDidRdCond010D SWTST_udtDcmCallBackDidRdCond010E SWTST_udtDcmCallBackDidRdCond010F SWTST_udtDcmCallBackDidRdCond0110 SWTST_udtDcmCallBackDidRdCond0111 SWTST_udtDcmCallBackDidRdCond0112 SWTST_udtDcmCallBackDidRdCond0113 SWTST_udtDcmCallBackDidRdCond0114 SWTST_udtDcmCallBackDidRdCond0115 SWTST_udtDcmCallBackDidRdCond0116 SWTST_udtDcmCallBackDidRdCond0130 SWTST_udtDcmCallBackDidRdCond0300 SWTST_udtDcmCallBackDidRdCond0301 SWTST_udtDcmCallBackDidRdCond0302 SWTST_udtDcmCallBackDidRdCond0303 SWTST_udtDcmCallBackDidRdCond0304 SWTST_udtDcmCallBackDidRdCond0305 SWTST_udtDcmCallBackDidRdCond0306 SWTST_udtDcmCallBackDidRdCond0307 SWTST_udtDcmCallBackDidRdCond0308 SWTST_udtDcmCallBackDidRdCond0309 SWTST_udtDcmCallBackDidRdCond0310 SWTST_udtDcmCallBackDidRdCond0311 SWTST_udtDcmCallBackDidRdCond0312 SWTST_udtDcmCallBackDidRdCond0313 SWTST_udtDcmCallBackDidRdCond0314 SWTST_udtDcmCallBackDidRdCond0315 SWTST_udtDcmCallBackDidRdCond0316 SWTST_udtDcmCallBackDidRdCond0317 SWTST_udtDcmCallBackDidRdCond0318 SWTST_udtDcmCallBackDidRdCond0319 SWTST_udtDcmCallBackDidRdCond0320 SWTST_udtDcmCallBackDidRdCond0321 SWTST_udtDcmCallBackDidRdCond0322 SWTST_udtDcmCallBackDidRdCond0400 SWTST_udtDcmCallBackDidRdCond0401 SWTST_udtDcmCallBackDidRdCond0402 SWTST_udtDcmCallBackDidRdCond0403 SWTST_udtDcmCallBackDidRdCond0404 SWTST_udtDcmCallBackDidRdCond0405 SWTST_udtDcmCallBackDidRdCond0406 SWTST_udtDcmCallBackDidRdCond0407 SWTST_udtDcmCallBackDidRdCondF190 SWTST_udtDcmCallBackDidRdCondF195 SWTST_udtDcmCallBackDidWrCond0130 SWTST_udtDcmCallBackDidWrCond0200 SWTST_udtDcmCallBackDidWrCond0201 SWTST_udtDcmCallBackDidWrCond0202 SWTST_udtDcmCallBackDidWrCond0203 SWTST_udtDcmCallBackDidWrCond0204 SWTST_udtDcmCallBackDidWrCond0205 SWTST_udtDcmCallBackDidWrCond0206 SWTST_udtDcmCallBackDidWrCond0207 SWTST_udtDcmCallBackDidWrCond0208 SWTST_udtDcmCallBackDidWrCond0209 SWTST_udtDcmCallBackDidWrCond0403 SWTST_udtDcmCallBackDidWrCond0404 SWTST_udtDcmCallBackDidWrCond0405 SWTST_udtDcmCallBackDidWrCond0406 SWTST_udtDcmCallBackDidWrCondF190 SWTST_udtDcmCallBackDidWrCondF195 SWTST_udtDcmDidForRdInfoType04 SWTST_udtDcmDidForRdInfoType04[0] SWTST_udtDcmDidForRdInfoType04[10] SWTST_udtDcmDidForRdInfoType04[11] SWTST_udtDcmDidForRdInfoType04[12] SWTST_udtDcmDidForRdInfoType04[13] SWTST_udtDcmDidForRdInfoType04[14] SWTST_udtDcmDidForRdInfoType04[15] SWTST_udtDcmDidForRdInfoType04[16] SWTST_udtDcmDidForRdInfoType04[1] SWTST_udtDcmDidForRdInfoType04[2] SWTST_udtDcmDidForRdInfoType04[3] SWTST_udtDcmDidForRdInfoType04[4] SWTST_udtDcmDidForRdInfoType04[5] SWTST_udtDcmDidForRdInfoType04[6] SWTST_udtDcmDidForRdInfoType04[7] SWTST_udtDcmDidForRdInfoType04[8] SWTST_udtDcmDidForRdInfoType04[9] SWTST_udtDcmDidForRdInfoType06 SWTST_udtDcmDidForRdInfoType06[0] SWTST_udtDcmDidForRdInfoType06[1] SWTST_udtDcmDidForRdInfoType06[2] SWTST_udtDcmDidForRdInfoType0A SWTST_udtDcmDidForRdInfoType0A[0] SWTST_udtDcmDidForRdInfoType0A[10] SWTST_udtDcmDidForRdInfoType0A[11] SWTST_udtDcmDidForRdInfoType0A[12] SWTST_udtDcmDidForRdInfoType0A[13] SWTST_udtDcmDidForRdInfoType0A[14] SWTST_udtDcmDidForRdInfoType0A[15] SWTST_udtDcmDidForRdInfoType0A[16] SWTST_udtDcmDidForRdInfoType0A[17] SWTST_udtDcmDidForRdInfoType0A[18] SWTST_udtDcmDidForRdInfoType0A[19] SWTST_udtDcmDidForRdInfoType0A[1] SWTST_udtDcmDidForRdInfoType0A[20] SWTST_udtDcmDidForRdInfoType0A[2] SWTST_udtDcmDidForRdInfoType0A[3] SWTST_udtDcmDidForRdInfoType0A[4] SWTST_udtDcmDidForRdInfoType0A[5] SWTST_udtDcmDidForRdInfoType0A[6] SWTST_udtDcmDidForRdInfoType0A[7] SWTST_udtDcmDidForRdInfoType0A[8] SWTST_udtDcmDidForRdInfoType0A[9] SWTST_udtDcmReqData SWTST_udtDcmReqData[0] SWTST_udtDcmReqData[100] SWTST_udtDcmReqData[101] SWTST_udtDcmReqData[102] SWTST_udtDcmReqData[103] SWTST_udtDcmReqData[104] SWTST_udtDcmReqData[105] SWTST_udtDcmReqData[106] SWTST_udtDcmReqData[107] SWTST_udtDcmReqData[108] SWTST_udtDcmReqData[109] SWTST_udtDcmReqData[10] SWTST_udtDcmReqData[110] SWTST_udtDcmReqData[111] SWTST_udtDcmReqData[112] SWTST_udtDcmReqData[113] SWTST_udtDcmReqData[114] SWTST_udtDcmReqData[115] SWTST_udtDcmReqData[116] SWTST_udtDcmReqData[117] SWTST_udtDcmReqData[118] SWTST_udtDcmReqData[119] SWTST_udtDcmReqData[11] SWTST_udtDcmReqData[120] SWTST_udtDcmReqData[121] SWTST_udtDcmReqData[122] SWTST_udtDcmReqData[123] SWTST_udtDcmReqData[124] SWTST_udtDcmReqData[125] SWTST_udtDcmReqData[126] SWTST_udtDcmReqData[127] SWTST_udtDcmReqData[128] SWTST_udtDcmReqData[129] SWTST_udtDcmReqData[12] SWTST_udtDcmReqData[130] SWTST_udtDcmReqData[131] SWTST_udtDcmReqData[132] SWTST_udtDcmReqData[133] SWTST_udtDcmReqData[134] SWTST_udtDcmReqData[135] SWTST_udtDcmReqData[136] SWTST_udtDcmReqData[137] SWTST_udtDcmReqData[138] SWTST_udtDcmReqData[139] SWTST_udtDcmReqData[13] SWTST_udtDcmReqData[140] SWTST_udtDcmReqData[141] SWTST_udtDcmReqData[142] SWTST_udtDcmReqData[143] SWTST_udtDcmReqData[144] SWTST_udtDcmReqData[145] SWTST_udtDcmReqData[146] SWTST_udtDcmReqData[147] SWTST_udtDcmReqData[148] SWTST_udtDcmReqData[149] SWTST_udtDcmReqData[14] SWTST_udtDcmReqData[150] SWTST_udtDcmReqData[151] SWTST_udtDcmReqData[152] SWTST_udtDcmReqData[153] SWTST_udtDcmReqData[154] SWTST_udtDcmReqData[155] SWTST_udtDcmReqData[156] SWTST_udtDcmReqData[157] SWTST_udtDcmReqData[158] SWTST_udtDcmReqData[159] SWTST_udtDcmReqData[15] SWTST_udtDcmReqData[160] SWTST_udtDcmReqData[161] SWTST_udtDcmReqData[162] SWTST_udtDcmReqData[163] SWTST_udtDcmReqData[164] SWTST_udtDcmReqData[165] SWTST_udtDcmReqData[166] SWTST_udtDcmReqData[167] SWTST_udtDcmReqData[168] SWTST_udtDcmReqData[169] SWTST_udtDcmReqData[16] SWTST_udtDcmReqData[170] SWTST_udtDcmReqData[171] SWTST_udtDcmReqData[172] SWTST_udtDcmReqData[173] SWTST_udtDcmReqData[174] SWTST_udtDcmReqData[175] SWTST_udtDcmReqData[176] SWTST_udtDcmReqData[177] SWTST_udtDcmReqData[178] SWTST_udtDcmReqData[179] SWTST_udtDcmReqData[17] SWTST_udtDcmReqData[180] SWTST_udtDcmReqData[181] SWTST_udtDcmReqData[182] SWTST_udtDcmReqData[183] SWTST_udtDcmReqData[184] SWTST_udtDcmReqData[185] SWTST_udtDcmReqData[186] SWTST_udtDcmReqData[187] SWTST_udtDcmReqData[188] SWTST_udtDcmReqData[189] SWTST_udtDcmReqData[18] SWTST_udtDcmReqData[190] SWTST_udtDcmReqData[191] SWTST_udtDcmReqData[192] SWTST_udtDcmReqData[193] SWTST_udtDcmReqData[194] SWTST_udtDcmReqData[195] SWTST_udtDcmReqData[196] SWTST_udtDcmReqData[197] SWTST_udtDcmReqData[198] SWTST_udtDcmReqData[199] SWTST_udtDcmReqData[19] SWTST_udtDcmReqData[1] SWTST_udtDcmReqData[20] SWTST_udtDcmReqData[21] SWTST_udtDcmReqData[22] SWTST_udtDcmReqData[23] SWTST_udtDcmReqData[24] SWTST_udtDcmReqData[25] SWTST_udtDcmReqData[26] SWTST_udtDcmReqData[27] SWTST_udtDcmReqData[28] SWTST_udtDcmReqData[29] SWTST_udtDcmReqData[2] SWTST_udtDcmReqData[30] SWTST_udtDcmReqData[31] SWTST_udtDcmReqData[32] SWTST_udtDcmReqData[33] SWTST_udtDcmReqData[34] SWTST_udtDcmReqData[35] SWTST_udtDcmReqData[36] SWTST_udtDcmReqData[37] SWTST_udtDcmReqData[38] SWTST_udtDcmReqData[39] SWTST_udtDcmReqData[3] SWTST_udtDcmReqData[40] SWTST_udtDcmReqData[41] SWTST_udtDcmReqData[42] SWTST_udtDcmReqData[43] SWTST_udtDcmReqData[44] SWTST_udtDcmReqData[45] SWTST_udtDcmReqData[46] SWTST_udtDcmReqData[47] SWTST_udtDcmReqData[48] SWTST_udtDcmReqData[49] SWTST_udtDcmReqData[4] SWTST_udtDcmReqData[50] SWTST_udtDcmReqData[51] SWTST_udtDcmReqData[52] SWTST_udtDcmReqData[53] SWTST_udtDcmReqData[54] SWTST_udtDcmReqData[55] SWTST_udtDcmReqData[56] SWTST_udtDcmReqData[57] SWTST_udtDcmReqData[58] SWTST_udtDcmReqData[59] SWTST_udtDcmReqData[5] SWTST_udtDcmReqData[60] SWTST_udtDcmReqData[61] SWTST_udtDcmReqData[62] SWTST_udtDcmReqData[63] SWTST_udtDcmReqData[64] SWTST_udtDcmReqData[65] SWTST_udtDcmReqData[66] SWTST_udtDcmReqData[67] SWTST_udtDcmReqData[68] SWTST_udtDcmReqData[69] SWTST_udtDcmReqData[6] SWTST_udtDcmReqData[70] SWTST_udtDcmReqData[71] SWTST_udtDcmReqData[72] SWTST_udtDcmReqData[73] SWTST_udtDcmReqData[74] SWTST_udtDcmReqData[75] SWTST_udtDcmReqData[76] SWTST_udtDcmReqData[77] SWTST_udtDcmReqData[78] SWTST_udtDcmReqData[79] SWTST_udtDcmReqData[7] SWTST_udtDcmReqData[80] SWTST_udtDcmReqData[81] SWTST_udtDcmReqData[82] SWTST_udtDcmReqData[83] SWTST_udtDcmReqData[84] SWTST_udtDcmReqData[85] SWTST_udtDcmReqData[86] SWTST_udtDcmReqData[87] SWTST_udtDcmReqData[88] SWTST_udtDcmReqData[89] SWTST_udtDcmReqData[8] SWTST_udtDcmReqData[90] SWTST_udtDcmReqData[91] SWTST_udtDcmReqData[92] SWTST_udtDcmReqData[93] SWTST_udtDcmReqData[94] SWTST_udtDcmReqData[95] SWTST_udtDcmReqData[96] SWTST_udtDcmReqData[97] SWTST_udtDcmReqData[98] SWTST_udtDcmReqData[99] SWTST_udtDcmReqData[9] SWTST_udtDcmReqDataSa SWTST_udtDcmReqDataSize SWTST_udtDcmReqErrCode SWTST_udtDcmReqSid SWTST_udtDcmReqType SWTST_vau8Btt6020OcFltTst SWTST_vau8Btt6020OcFltTst[0] SWTST_vau8Btt6020OcFltTst[1] SWTST_vau8Btt6020OcFltTst[2] SWTST_vau8Btt6020OcFltTst[3] SWTST_vbAdcTstDone SWTST_vbAdcTstErr SWTST_vbBtt6020TstDone SWTST_vbBtt6020TstErr SWTST_vbCalibTstDone SWTST_vbCalibTstErr SWTST_vbComTstDone SWTST_vbComTstErr SWTST_vbDiagcTstDone SWTST_vbDiagcTstErr SWTST_vbDioTstDone SWTST_vbDioTstErr SWTST_vbFimTstDone SWTST_vbFimTstErr SWTST_vbSftyTstDone SWTST_vbSftyTstErr SWTST_vbTle62X0TstDone SWTST_vbTle62X0TstErr SWTST_vbTle8242TstDone SWTST_vbTle8242TstErr SWTST_vbTrimTstDone SWTST_vbTrimTstErr SWTST_vbWdgTstDone SWTST_vbWdgTstErr SWTST_vidDiagcCalCnt SWTST_vidDiagcCalCnt[0] SWTST_vidDiagcCalCnt[10] SWTST_vidDiagcCalCnt[11] SWTST_vidDiagcCalCnt[12] SWTST_vidDiagcCalCnt[13] SWTST_vidDiagcCalCnt[14] SWTST_vidDiagcCalCnt[15] SWTST_vidDiagcCalCnt[16] SWTST_vidDiagcCalCnt[17] SWTST_vidDiagcCalCnt[18] SWTST_vidDiagcCalCnt[19] SWTST_vidDiagcCalCnt[1] SWTST_vidDiagcCalCnt[20] SWTST_vidDiagcCalCnt[21] SWTST_vidDiagcCalCnt[22] SWTST_vidDiagcCalCnt[23] SWTST_vidDiagcCalCnt[24] SWTST_vidDiagcCalCnt[25] SWTST_vidDiagcCalCnt[26] SWTST_vidDiagcCalCnt[27] SWTST_vidDiagcCalCnt[28] SWTST_vidDiagcCalCnt[29] SWTST_vidDiagcCalCnt[2] SWTST_vidDiagcCalCnt[30] SWTST_vidDiagcCalCnt[31] SWTST_vidDiagcCalCnt[32] SWTST_vidDiagcCalCnt[33] SWTST_vidDiagcCalCnt[34] SWTST_vidDiagcCalCnt[35] SWTST_vidDiagcCalCnt[36] SWTST_vidDiagcCalCnt[37] SWTST_vidDiagcCalCnt[38] SWTST_vidDiagcCalCnt[39] SWTST_vidDiagcCalCnt[3] SWTST_vidDiagcCalCnt[40] SWTST_vidDiagcCalCnt[41] SWTST_vidDiagcCalCnt[42] SWTST_vidDiagcCalCnt[43] SWTST_vidDiagcCalCnt[44] SWTST_vidDiagcCalCnt[45] SWTST_vidDiagcCalCnt[46] SWTST_vidDiagcCalCnt[47] SWTST_vidDiagcCalCnt[48] SWTST_vidDiagcCalCnt[49] SWTST_vidDiagcCalCnt[4] SWTST_vidDiagcCalCnt[50] SWTST_vidDiagcCalCnt[51] SWTST_vidDiagcCalCnt[52] SWTST_vidDiagcCalCnt[53] SWTST_vidDiagcCalCnt[54] SWTST_vidDiagcCalCnt[55] SWTST_vidDiagcCalCnt[56] SWTST_vidDiagcCalCnt[57] SWTST_vidDiagcCalCnt[58] SWTST_vidDiagcCalCnt[59] SWTST_vidDiagcCalCnt[5] SWTST_vidDiagcCalCnt[60] SWTST_vidDiagcCalCnt[61] SWTST_vidDiagcCalCnt[62] SWTST_vidDiagcCalCnt[63] SWTST_vidDiagcCalCnt[64] SWTST_vidDiagcCalCnt[65] SWTST_vidDiagcCalCnt[66] SWTST_vidDiagcCalCnt[67] SWTST_vidDiagcCalCnt[68] SWTST_vidDiagcCalCnt[69] SWTST_vidDiagcCalCnt[6] SWTST_vidDiagcCalCnt[70] SWTST_vidDiagcCalCnt[71] SWTST_vidDiagcCalCnt[72] SWTST_vidDiagcCalCnt[7] SWTST_vidDiagcCalCnt[8] SWTST_vidDiagcCalCnt[9] SWTST_vidDiagcDecTstEn SWTST_vidDiagcMaxCnt SWTST_vidDiagcMaxCnt[0] SWTST_vidDiagcMaxCnt[10] SWTST_vidDiagcMaxCnt[11] SWTST_vidDiagcMaxCnt[12] SWTST_vidDiagcMaxCnt[13] SWTST_vidDiagcMaxCnt[14] SWTST_vidDiagcMaxCnt[15] SWTST_vidDiagcMaxCnt[16] SWTST_vidDiagcMaxCnt[17] SWTST_vidDiagcMaxCnt[18] SWTST_vidDiagcMaxCnt[19] SWTST_vidDiagcMaxCnt[1] SWTST_vidDiagcMaxCnt[20] SWTST_vidDiagcMaxCnt[21] SWTST_vidDiagcMaxCnt[22] SWTST_vidDiagcMaxCnt[23] SWTST_vidDiagcMaxCnt[24] SWTST_vidDiagcMaxCnt[25] SWTST_vidDiagcMaxCnt[26] SWTST_vidDiagcMaxCnt[27] SWTST_vidDiagcMaxCnt[28] SWTST_vidDiagcMaxCnt[29] SWTST_vidDiagcMaxCnt[2] SWTST_vidDiagcMaxCnt[30] SWTST_vidDiagcMaxCnt[31] SWTST_vidDiagcMaxCnt[32] SWTST_vidDiagcMaxCnt[33] SWTST_vidDiagcMaxCnt[34] SWTST_vidDiagcMaxCnt[35] SWTST_vidDiagcMaxCnt[36] SWTST_vidDiagcMaxCnt[37] SWTST_vidDiagcMaxCnt[38] SWTST_vidDiagcMaxCnt[39] SWTST_vidDiagcMaxCnt[3] SWTST_vidDiagcMaxCnt[40] SWTST_vidDiagcMaxCnt[41] SWTST_vidDiagcMaxCnt[42] SWTST_vidDiagcMaxCnt[43] SWTST_vidDiagcMaxCnt[44] SWTST_vidDiagcMaxCnt[45] SWTST_vidDiagcMaxCnt[46] SWTST_vidDiagcMaxCnt[47] SWTST_vidDiagcMaxCnt[48] SWTST_vidDiagcMaxCnt[49] SWTST_vidDiagcMaxCnt[4] SWTST_vidDiagcMaxCnt[50] SWTST_vidDiagcMaxCnt[51] SWTST_vidDiagcMaxCnt[52] SWTST_vidDiagcMaxCnt[53] SWTST_vidDiagcMaxCnt[54] SWTST_vidDiagcMaxCnt[55] SWTST_vidDiagcMaxCnt[56] SWTST_vidDiagcMaxCnt[57] SWTST_vidDiagcMaxCnt[58] SWTST_vidDiagcMaxCnt[59] SWTST_vidDiagcMaxCnt[5] SWTST_vidDiagcMaxCnt[60] SWTST_vidDiagcMaxCnt[61] SWTST_vidDiagcMaxCnt[62] SWTST_vidDiagcMaxCnt[63] SWTST_vidDiagcMaxCnt[64] SWTST_vidDiagcMaxCnt[65] SWTST_vidDiagcMaxCnt[66] SWTST_vidDiagcMaxCnt[6] SWTST_vidDiagcMaxCnt[7] SWTST_vidDiagcMaxCnt[8] SWTST_vidDiagcMaxCnt[9] SWTST_vidDiagcMaxCntFlg SWTST_vidDiagcMaxCntFlg[0] SWTST_vidDiagcMaxCntFlg[10] SWTST_vidDiagcMaxCntFlg[11] SWTST_vidDiagcMaxCntFlg[12] SWTST_vidDiagcMaxCntFlg[13] SWTST_vidDiagcMaxCntFlg[14] SWTST_vidDiagcMaxCntFlg[15] SWTST_vidDiagcMaxCntFlg[16] SWTST_vidDiagcMaxCntFlg[17] SWTST_vidDiagcMaxCntFlg[18] SWTST_vidDiagcMaxCntFlg[19] SWTST_vidDiagcMaxCntFlg[1] SWTST_vidDiagcMaxCntFlg[20] SWTST_vidDiagcMaxCntFlg[21] SWTST_vidDiagcMaxCntFlg[22] SWTST_vidDiagcMaxCntFlg[23] SWTST_vidDiagcMaxCntFlg[24] SWTST_vidDiagcMaxCntFlg[25] SWTST_vidDiagcMaxCntFlg[26] SWTST_vidDiagcMaxCntFlg[27] SWTST_vidDiagcMaxCntFlg[28] SWTST_vidDiagcMaxCntFlg[29] SWTST_vidDiagcMaxCntFlg[2] SWTST_vidDiagcMaxCntFlg[30] SWTST_vidDiagcMaxCntFlg[31] SWTST_vidDiagcMaxCntFlg[32] SWTST_vidDiagcMaxCntFlg[33] SWTST_vidDiagcMaxCntFlg[34] SWTST_vidDiagcMaxCntFlg[35] SWTST_vidDiagcMaxCntFlg[36] SWTST_vidDiagcMaxCntFlg[37] SWTST_vidDiagcMaxCntFlg[38] SWTST_vidDiagcMaxCntFlg[39] SWTST_vidDiagcMaxCntFlg[3] SWTST_vidDiagcMaxCntFlg[40] SWTST_vidDiagcMaxCntFlg[41] SWTST_vidDiagcMaxCntFlg[42] SWTST_vidDiagcMaxCntFlg[43] SWTST_vidDiagcMaxCntFlg[44] SWTST_vidDiagcMaxCntFlg[45] SWTST_vidDiagcMaxCntFlg[46] SWTST_vidDiagcMaxCntFlg[47] SWTST_vidDiagcMaxCntFlg[48] SWTST_vidDiagcMaxCntFlg[49] SWTST_vidDiagcMaxCntFlg[4] SWTST_vidDiagcMaxCntFlg[50] SWTST_vidDiagcMaxCntFlg[51] SWTST_vidDiagcMaxCntFlg[52] SWTST_vidDiagcMaxCntFlg[53] SWTST_vidDiagcMaxCntFlg[54] SWTST_vidDiagcMaxCntFlg[55] SWTST_vidDiagcMaxCntFlg[56] SWTST_vidDiagcMaxCntFlg[57] SWTST_vidDiagcMaxCntFlg[58] SWTST_vidDiagcMaxCntFlg[59] SWTST_vidDiagcMaxCntFlg[5] SWTST_vidDiagcMaxCntFlg[60] SWTST_vidDiagcMaxCntFlg[61] SWTST_vidDiagcMaxCntFlg[62] SWTST_vidDiagcMaxCntFlg[63] SWTST_vidDiagcMaxCntFlg[64] SWTST_vidDiagcMaxCntFlg[65] SWTST_vidDiagcMaxCntFlg[66] SWTST_vidDiagcMaxCntFlg[6] SWTST_vidDiagcMaxCntFlg[7] SWTST_vidDiagcMaxCntFlg[8] SWTST_vidDiagcMaxCntFlg[9] SWTST_vidSolCompRes SWTST_vu32Dm07MsgSpn SWTST_vu8AdcRunngTstNr SWTST_vu8Btt6020OverLoadFltTst SWTST_vu8Btt6020OverLoadFltTst[0] SWTST_vu8Btt6020OverLoadFltTst[1] SWTST_vu8Btt6020OverLoadFltTst[2] SWTST_vu8Btt6020OverLoadFltTst[3] SWTST_vu8Btt6020RunngTstNr SWTST_vu8Btt6020ScFltTst SWTST_vu8Btt6020ScFltTst[0] SWTST_vu8Btt6020ScFltTst[1] SWTST_vu8Btt6020ScFltTst[2] SWTST_vu8Btt6020ScFltTst[3] SWTST_vu8Btt6020ScsFltTst SWTST_vu8Btt6020ScsFltTst[0] SWTST_vu8Btt6020ScsFltTst[1] SWTST_vu8Btt6020ScsFltTst[2] SWTST_vu8Btt6020ScsFltTst[3] SWTST_vu8BTT6030OcFltTst SWTST_vu8BTT6030OcFltTst[0] SWTST_vu8BTT6030OcFltTst[1] SWTST_vu8BTT6030OcFltTst[2] SWTST_vu8BTT6030OcFltTst[3] SWTST_vu8BTT6030ScFltTst SWTST_vu8BTT6030ScFltTst[0] SWTST_vu8BTT6030ScFltTst[1] SWTST_vu8BTT6030ScFltTst[2] SWTST_vu8BTT6030ScFltTst[3] SWTST_vu8BTT6030ScsFltTst SWTST_vu8BTT6030ScsFltTst[0] SWTST_vu8BTT6030ScsFltTst[1] SWTST_vu8BTT6030ScsFltTst[2] SWTST_vu8BTT6030ScsFltTst[3] SWTST_vu8CalibRunngTstNr SWTST_vu8ComRunngTstNr SWTST_vu8DiagcRunngTstNr SWTST_vu8DioRunngTstNr SWTST_vu8Dm07Mod SWTST_vu8Dm07MsgFmi SWTST_vu8Dm07MsgTid SWTST_vu8Dm30Data SWTST_vu8Dm30Data[0] SWTST_vu8Dm30Data[10] SWTST_vu8Dm30Data[11] SWTST_vu8Dm30Data[12] SWTST_vu8Dm30Data[13] SWTST_vu8Dm30Data[14] SWTST_vu8Dm30Data[15] SWTST_vu8Dm30Data[16] SWTST_vu8Dm30Data[17] SWTST_vu8Dm30Data[18] SWTST_vu8Dm30Data[19] SWTST_vu8Dm30Data[1] SWTST_vu8Dm30Data[20] SWTST_vu8Dm30Data[21] SWTST_vu8Dm30Data[22] SWTST_vu8Dm30Data[23] SWTST_vu8Dm30Data[24] SWTST_vu8Dm30Data[25] SWTST_vu8Dm30Data[26] SWTST_vu8Dm30Data[27] SWTST_vu8Dm30Data[28] SWTST_vu8Dm30Data[29] SWTST_vu8Dm30Data[2] SWTST_vu8Dm30Data[30] SWTST_vu8Dm30Data[31] SWTST_vu8Dm30Data[32] SWTST_vu8Dm30Data[33] SWTST_vu8Dm30Data[34] SWTST_vu8Dm30Data[35] SWTST_vu8Dm30Data[36] SWTST_vu8Dm30Data[37] SWTST_vu8Dm30Data[38] SWTST_vu8Dm30Data[39] SWTST_vu8Dm30Data[3] SWTST_vu8Dm30Data[40] SWTST_vu8Dm30Data[41] SWTST_vu8Dm30Data[42] SWTST_vu8Dm30Data[43] SWTST_vu8Dm30Data[44] SWTST_vu8Dm30Data[45] SWTST_vu8Dm30Data[46] SWTST_vu8Dm30Data[47] SWTST_vu8Dm30Data[48] SWTST_vu8Dm30Data[49] SWTST_vu8Dm30Data[4] SWTST_vu8Dm30Data[50] SWTST_vu8Dm30Data[51] SWTST_vu8Dm30Data[52] SWTST_vu8Dm30Data[53] SWTST_vu8Dm30Data[54] SWTST_vu8Dm30Data[55] SWTST_vu8Dm30Data[56] SWTST_vu8Dm30Data[57] SWTST_vu8Dm30Data[58] SWTST_vu8Dm30Data[59] SWTST_vu8Dm30Data[5] SWTST_vu8Dm30Data[60] SWTST_vu8Dm30Data[61] SWTST_vu8Dm30Data[62] SWTST_vu8Dm30Data[63] SWTST_vu8Dm30Data[64] SWTST_vu8Dm30Data[65] SWTST_vu8Dm30Data[66] SWTST_vu8Dm30Data[67] SWTST_vu8Dm30Data[68] SWTST_vu8Dm30Data[69] SWTST_vu8Dm30Data[6] SWTST_vu8Dm30Data[70] SWTST_vu8Dm30Data[71] SWTST_vu8Dm30Data[72] SWTST_vu8Dm30Data[73] SWTST_vu8Dm30Data[74] SWTST_vu8Dm30Data[75] SWTST_vu8Dm30Data[76] SWTST_vu8Dm30Data[77] SWTST_vu8Dm30Data[78] SWTST_vu8Dm30Data[79] SWTST_vu8Dm30Data[7] SWTST_vu8Dm30Data[80] SWTST_vu8Dm30Data[81] SWTST_vu8Dm30Data[82] SWTST_vu8Dm30Data[83] SWTST_vu8Dm30Data[84] SWTST_vu8Dm30Data[85] SWTST_vu8Dm30Data[86] SWTST_vu8Dm30Data[87] SWTST_vu8Dm30Data[88] SWTST_vu8Dm30Data[89] SWTST_vu8Dm30Data[8] SWTST_vu8Dm30Data[90] SWTST_vu8Dm30Data[91] SWTST_vu8Dm30Data[92] SWTST_vu8Dm30Data[93] SWTST_vu8Dm30Data[94] SWTST_vu8Dm30Data[95] SWTST_vu8Dm30Data[96] SWTST_vu8Dm30Data[97] SWTST_vu8Dm30Data[98] SWTST_vu8Dm30Data[99] SWTST_vu8Dm30Data[9] SWTST_vu8Dm30MsgLen SWTST_vu8FimRunngTstNr SWTST_vu8LostCommFltTst SWTST_vu8LostCommFltTst[0] SWTST_vu8LostCommFltTst[1] SWTST_vu8LostCommFltTst[2] SWTST_vu8LostCommFltTst[3] SWTST_vu8LostCommFltTst[4] SWTST_vu8LostCommFltTst[5] SWTST_vu8LostCommFltTst[6] SWTST_vu8LostCommFltTst[7] SWTST_vu8SftyRunngTstNr SWTST_vu8TLE62X0OpenFltTst SWTST_vu8TLE62X0OpenFltTst[0] SWTST_vu8TLE62X0OpenFltTst[10] SWTST_vu8TLE62X0OpenFltTst[11] SWTST_vu8TLE62X0OpenFltTst[1] SWTST_vu8TLE62X0OpenFltTst[2] SWTST_vu8TLE62X0OpenFltTst[3] SWTST_vu8TLE62X0OpenFltTst[4] SWTST_vu8TLE62X0OpenFltTst[5] SWTST_vu8TLE62X0OpenFltTst[6] SWTST_vu8TLE62X0OpenFltTst[7] SWTST_vu8TLE62X0OpenFltTst[8] SWTST_vu8TLE62X0OpenFltTst[9] SWTST_vu8Tle62X0RunngTstNr SWTST_vu8TLE62X0ScFltTst SWTST_vu8TLE62X0ScFltTst[0] SWTST_vu8TLE62X0ScFltTst[10] SWTST_vu8TLE62X0ScFltTst[11] SWTST_vu8TLE62X0ScFltTst[1] SWTST_vu8TLE62X0ScFltTst[2] SWTST_vu8TLE62X0ScFltTst[3] SWTST_vu8TLE62X0ScFltTst[4] SWTST_vu8TLE62X0ScFltTst[5] SWTST_vu8TLE62X0ScFltTst[6] SWTST_vu8TLE62X0ScFltTst[7] SWTST_vu8TLE62X0ScFltTst[8] SWTST_vu8TLE62X0ScFltTst[9] SWTST_vu8TLE62X0ScsFltTst SWTST_vu8TLE62X0ScsFltTst[0] SWTST_vu8TLE62X0ScsFltTst[10] SWTST_vu8TLE62X0ScsFltTst[11] SWTST_vu8TLE62X0ScsFltTst[1] SWTST_vu8TLE62X0ScsFltTst[2] SWTST_vu8TLE62X0ScsFltTst[3] SWTST_vu8TLE62X0ScsFltTst[4] SWTST_vu8TLE62X0ScsFltTst[5] SWTST_vu8TLE62X0ScsFltTst[6] SWTST_vu8TLE62X0ScsFltTst[7] SWTST_vu8TLE62X0ScsFltTst[8] SWTST_vu8TLE62X0ScsFltTst[9] SWTST_vu8Tle8242RunngTstNr SWTST_vu8TrimRunngTstNr SWTST_vu8WdgRunngTstNr TST_PWD_u32_ENG_SPD_HALL_PWM_DUTYCYC TST_PWD_u32_ENG_SPD_HALL_PWM_FRQ TST_PWD_u32_ENG_SPD_VR_PWM_DUTYCYC TST_PWD_u32_ENG_SPD_VR_PWM_FRQ TST_PWD_u32_INPUT_SPD_HALL_PWM_DUTYCYC TST_PWD_u32_INPUT_SPD_HALL_PWM_FRQ TST_PWD_u32_INPUT_SPD_VR_PWM_DUTYCYC TST_PWD_u32_INPUT_SPD_VR_PWM_FRQ TST_PWD_u32_OUTPUT_SPD_HALL_PWM_DUTYCYC TST_PWD_u32_OUTPUT_SPD_HALL_PWM_FRQ TST_PWD_u32_OUTPUT_SPD_VR_PWM_DUTYCYC TST_PWD_u32_OUTPUT_SPD_VR_PWM_FRQ TST_PWD_u32_PWM_IN_1_DUTYCYC TST_PWD_u32_PWM_IN_1_FRQ TST_PWD_u32_PWM_IN_2_DUTYCYC TST_PWD_u32_PWM_IN_2_FRQ TST_PWD_u32_PWM_IN_3_DUTYCYC TST_PWD_u32_PWM_IN_3_FRQ TST_PWD_u32EngSpdHallPwmTon TST_PWD_u32InpSpdHallPwmTon TST_PWD_u32OutpSpdHallPwmTon TST_PWM_bPWM_ENA_AUXILIARIES_ON_OFF_VALVE TST_PWM_bPWM_ENA_DUAL_AREA_PISTON_SOLENOID TST_PWM_bPWM_ENA_LIMP_HOME_SAFE TST_PWM_bPWM_ENA_RETARDER_ACCUMULATOR TST_PWM_bPWM_ENA_SEL_COOLING TST_PWM_f32PWM_FRQ_AUXILIARIES_ON_OFF_VALVE TST_PWM_f32PWM_FRQ_DUAL_AREA_PISTON_SOLENOID TST_PWM_f32PWM_FRQ_LIMP_HOME_SAFE TST_PWM_f32PWM_FRQ_RETARDER_ACCUMULATOR TST_PWM_f32PWM_FRQ_SEL_COOLING TST_PWM_s16PCS_AUX_DUTYCYC TST_PWM_s16PCS_B1_DUTYCYC TST_PWM_s16PCS_B2_DUTYCYC TST_PWM_s16PCS_B3_DUTYCYC TST_PWM_s16PCS_B4_DUTYCYC TST_PWM_s16PCS_C1_DUTYCYC TST_PWM_s16PCS_C2_DUTYCYC TST_PWM_s16PCS_LUC_DUTYCYC TST_PWM_s16PCS_MLP_DUTYCYC TST_PWM_s16PCS_RET_DUTYCYC TST_PWM_s16PWM_DUTY_AUXILIARIES_ON_OFF_VALVE TST_PWM_s16PWM_DUTY_DUAL_AREA_PISTON_SOLENOID TST_PWM_s16PWM_DUTY_LIMP_HOME_SAFE TST_PWM_s16PWM_DUTY_RETARDER_ACCUMULATOR TST_PWM_s16PWM_DUTY_SEL_COOLING TST_PWM_u32PCS_G1_FRQ TST_PWM_u32PCS_G2_FRQ TST_PWM_u32PCS_G3_FRQ TST_PWM_u32PCS_G4_FRQ TST_StackMeas_au32MaxUsg TST_StackMeas_au32MaxUsg[0] TST_StackMeas_au32MaxUsg[1] TST_StackMeas_au32MaxUsg[2] TST_StackMeas_au32StackSize TST_StackMeas_au32StackSize[0] TST_StackMeas_au32StackSize[1] TST_StackMeas_au32StackSize[2] TST_StackMeas_u32RdOutofRng TST_StackMeas_u8TstCaseSel TST_TRIM_af32g_G TST_TRIM_af32g_G[0] TST_TRIM_af32g_G[10] TST_TRIM_af32g_G[11] TST_TRIM_af32g_G[12] TST_TRIM_af32g_G[13] TST_TRIM_af32g_G[14] TST_TRIM_af32g_G[1] TST_TRIM_af32g_G[2] TST_TRIM_af32g_G[3] TST_TRIM_af32g_G[4] TST_TRIM_af32g_G[5] TST_TRIM_af32g_G[6] TST_TRIM_af32g_G[7] TST_TRIM_af32g_G[8] TST_TRIM_af32g_G[9] TST_TRIM_af32g_O TST_TRIM_af32g_O[0] TST_TRIM_af32g_O[10] TST_TRIM_af32g_O[11] TST_TRIM_af32g_O[12] TST_TRIM_af32g_O[13] TST_TRIM_af32g_O[14] TST_TRIM_af32g_O[1] TST_TRIM_af32g_O[2] TST_TRIM_af32g_O[3] TST_TRIM_af32g_O[4] TST_TRIM_af32g_O[5] TST_TRIM_af32g_O[6] TST_TRIM_af32g_O[7] TST_TRIM_af32g_O[8] TST_TRIM_af32g_O[9] TST_TRIM_af32Gt2 TST_TRIM_af32Gt2[0] TST_TRIM_af32Gt2[10] TST_TRIM_af32Gt2[11] TST_TRIM_af32Gt2[12] TST_TRIM_af32Gt2[13] TST_TRIM_af32Gt2[14] TST_TRIM_af32Gt2[1] TST_TRIM_af32Gt2[2] TST_TRIM_af32Gt2[3] TST_TRIM_af32Gt2[4] TST_TRIM_af32Gt2[5] TST_TRIM_af32Gt2[6] TST_TRIM_af32Gt2[7] TST_TRIM_af32Gt2[8] TST_TRIM_af32Gt2[9] TST_TRIM_af32o_G TST_TRIM_af32o_G[0] TST_TRIM_af32o_G[10] TST_TRIM_af32o_G[11] TST_TRIM_af32o_G[12] TST_TRIM_af32o_G[13] TST_TRIM_af32o_G[14] TST_TRIM_af32o_G[1] TST_TRIM_af32o_G[2] TST_TRIM_af32o_G[3] TST_TRIM_af32o_G[4] TST_TRIM_af32o_G[5] TST_TRIM_af32o_G[6] TST_TRIM_af32o_G[7] TST_TRIM_af32o_G[8] TST_TRIM_af32o_G[9] TST_TRIM_af32o_O TST_TRIM_af32o_O[0] TST_TRIM_af32o_O[10] TST_TRIM_af32o_O[11] TST_TRIM_af32o_O[12] TST_TRIM_af32o_O[13] TST_TRIM_af32o_O[14] TST_TRIM_af32o_O[1] TST_TRIM_af32o_O[2] TST_TRIM_af32o_O[3] TST_TRIM_af32o_O[4] TST_TRIM_af32o_O[5] TST_TRIM_af32o_O[6] TST_TRIM_af32o_O[7] TST_TRIM_af32o_O[8] TST_TRIM_af32o_O[9] TST_TRIM_af32Ot2 TST_TRIM_af32Ot2[0] TST_TRIM_af32Ot2[10] TST_TRIM_af32Ot2[11] TST_TRIM_af32Ot2[12] TST_TRIM_af32Ot2[13] TST_TRIM_af32Ot2[14] TST_TRIM_af32Ot2[1] TST_TRIM_af32Ot2[2] TST_TRIM_af32Ot2[3] TST_TRIM_af32Ot2[4] TST_TRIM_af32Ot2[5] TST_TRIM_af32Ot2[6] TST_TRIM_af32Ot2[7] TST_TRIM_af32Ot2[8] TST_TRIM_af32Ot2[9] TST_TRIM_f32T2 TST_TRIM_u8TstMod TST_u8OpCycleChangeFlagCCP TSTDV_af32TarCnrtMa TSTDV_af32TarCnrtMa[0] TSTDV_af32TarCnrtMa[10] TSTDV_af32TarCnrtMa[11] TSTDV_af32TarCnrtMa[12] TSTDV_af32TarCnrtMa[13] TSTDV_af32TarCnrtMa[14] TSTDV_af32TarCnrtMa[1] TSTDV_af32TarCnrtMa[2] TSTDV_af32TarCnrtMa[3] TSTDV_af32TarCnrtMa[4] TSTDV_af32TarCnrtMa[5] TSTDV_af32TarCnrtMa[6] TSTDV_af32TarCnrtMa[7] TSTDV_af32TarCnrtMa[8] TSTDV_af32TarCnrtMa[9] TSTDV_au8CmnHSDTstEna TSTDV_au8CmnHSDTstEna[0] TSTDV_au8CmnHSDTstEna[1] TSTDV_au8CmnHSDTstEna[2] TSTDV_au8CmnHSDTstEna[3] TSTDV_au8CmnLSDTstEna TSTDV_au8CmnLSDTstEna[0] TSTDV_au8CmnLSDTstEna[10] TSTDV_au8CmnLSDTstEna[11] TSTDV_au8CmnLSDTstEna[1] TSTDV_au8CmnLSDTstEna[2] TSTDV_au8CmnLSDTstEna[3] TSTDV_au8CmnLSDTstEna[4] TSTDV_au8CmnLSDTstEna[5] TSTDV_au8CmnLSDTstEna[6] TSTDV_au8CmnLSDTstEna[7] TSTDV_au8CmnLSDTstEna[8] TSTDV_au8CmnLSDTstEna[9] TSTDV_au8SoleHSDTstEna TSTDV_au8SoleHSDTstEna[0] TSTDV_au8SoleHSDTstEna[1] TSTDV_au8SoleHSDTstEna[2] TSTDV_au8SoleHSDTstEna[3] TSTDV_au8SoleTstEna TSTDV_au8SoleTstEna[0] TSTDV_au8SoleTstEna[10] TSTDV_au8SoleTstEna[11] TSTDV_au8SoleTstEna[12] TSTDV_au8SoleTstEna[13] TSTDV_au8SoleTstEna[14] TSTDV_au8SoleTstEna[1] TSTDV_au8SoleTstEna[2] TSTDV_au8SoleTstEna[3] TSTDV_au8SoleTstEna[4] TSTDV_au8SoleTstEna[5] TSTDV_au8SoleTstEna[6] TSTDV_au8SoleTstEna[7] TSTDV_au8SoleTstEna[8] TSTDV_au8SoleTstEna[9] TSTDV_u8TstCurIdx TSTDV_u8TstIdx TSTDV_u8TstIdxChgReq TSTDV_u8TstIdxReq TSTDV_u8TstSubIdx TSTDV_vu16SpdoDuty TSTDV_vu32SpdoFrq /end OUT_MEASUREMENT
/end FUNCTION
/end MODULE
/end PROJECT
