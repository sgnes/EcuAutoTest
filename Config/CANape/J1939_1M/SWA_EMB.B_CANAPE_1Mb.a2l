ASAP2_VERSION 1 70
/begin PROJECT TEST_PROJECT "TEST_PROJECT"
/begin HEADER "TEST_PROJECT" PROJECT_NO D0 VERSION "3095.02" /end HEADER
/begin MODULE TEST_PROJECT "TestSupplier"
/begin MOD_COMMON "" DEPOSIT ABSOLUTE BYTE_ORDER MSB_LAST ALIGNMENT_BYTE 1 ALIGNMENT_WORD 2 ALIGNMENT_LONG 4 ALIGNMENT_INT64 1 ALIGNMENT_FLOAT32_IEEE 4 ALIGNMENT_FLOAT64_IEEE 8 /end MOD_COMMON
/begin RECORD_LAYOUT DATA_RECORD_UBYTE FNC_VALUES 1 UBYTE ROW_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT DATA_RECORD_UWORD FNC_VALUES 1 UWORD ROW_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT DATA_RECORD_ULONG FNC_VALUES 1 ULONG ROW_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT DATA_RECORD_SLONG FNC_VALUES 1 SLONG ROW_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT DATA_RECORD_FLOAT32_IEEE FNC_VALUES 1 FLOAT32_IEEE ROW_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT AXIS_PTS_X_UBYTE_VEMS AXIS_PTS_X 1 UBYTE INDEX_INCR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT AXIS_PTS_X_SBYTE_VEMS AXIS_PTS_X 1 SBYTE INDEX_INCR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT AXIS_PTS_X_UWORD_VEMS AXIS_PTS_X 1 UWORD INDEX_INCR DIRECT /end RECORD_LAYOUT
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve11Underload "BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve11Underload" VALUE 0x80301FF6 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve12GeneralFault "BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve12GeneralFault" VALUE 0x80301FF8 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve12Open "BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve12Open" VALUE 0x80301FFA DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve12Overload "BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve12Overload" VALUE 0x80301FFC DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve12ShortToBatt "BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve12ShortToBatt" VALUE 0x80301FFE DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve12ShortToGndOpenCircuit "BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve12ShortToGndOpenCircuit" VALUE 0x80302000 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve12Underload "BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve12Underload" VALUE 0x80302002 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve13GeneralFault "BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve13GeneralFault" VALUE 0x80302004 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve13Open "BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve13Open" VALUE 0x80302006 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve13Overload "BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve13Overload" VALUE 0x80302008 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve13ShortToBatt "BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve13ShortToBatt" VALUE 0x8030200A DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve13ShortToGndOpenCircuit "BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve13ShortToGndOpenCircuit" VALUE 0x8030200C DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve13Underload "BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve13Underload" VALUE 0x8030200E DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve44GeneralFault "BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve44GeneralFault" VALUE 0x80302010 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve44Open "BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve44Open" VALUE 0x80302012 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve44Overload "BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve44Overload" VALUE 0x80302014 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve44ShortToBatt "BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve44ShortToBatt" VALUE 0x80302016 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve44ShortToGndOpenCircuit "BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve44ShortToGndOpenCircuit" VALUE 0x80302018 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve44Underload "BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve44Underload" VALUE 0x8030201A DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve45GeneralFault "BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve45GeneralFault" VALUE 0x8030201C DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve45Open "BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve45Open" VALUE 0x8030201E DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve45Overload "BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve45Overload" VALUE 0x80302020 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve45ShortToBatt "BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve45ShortToBatt" VALUE 0x80302022 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve45ShortToGnd "BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve45ShortToGnd" VALUE 0x80302024 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve45Underload "BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve45Underload" VALUE 0x80302026 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd1OpenCircuit "BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd1OpenCircuit" VALUE 0x8030204A DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd1Overload "BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd1Overload" VALUE 0x8030204C DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd1ShortToBattOpenCircuit "BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd1ShortToBattOpenCircuit" VALUE 0x8030204E DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd1ShortToGnd "BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd1ShortToGnd" VALUE 0x80302050 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd1Underload "BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd1Underload" VALUE 0x80302052 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd2OpenCircuit "BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd2OpenCircuit" VALUE 0x80302054 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd2Overload "BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd2Overload" VALUE 0x80302056 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd2ShortToBattOpenCircuit "BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd2ShortToBattOpenCircuit" VALUE 0x80302058 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd2ShortToGnd "BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd2ShortToGnd" VALUE 0x8030205A DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd2Underload "BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd2Underload" VALUE 0x8030205C DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd3OpenCircuit "BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd3OpenCircuit" VALUE 0x8030205E DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd3Overload "BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd3Overload" VALUE 0x80302060 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd3ShortToBattOpenCircuit "BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd3ShortToBattOpenCircuit" VALUE 0x80302062 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd3ShortToGnd "BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd3ShortToGnd" VALUE 0x80302064 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd3Underload "BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd3Underload" VALUE 0x80302066 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd4OpenCircuit "BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd4OpenCircuit" VALUE 0x80302068 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd4Overload "BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd4Overload" VALUE 0x8030206A DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd4ShortToBattOpenCircuit "BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd4ShortToBattOpenCircuit" VALUE 0x8030206C DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd4ShortToGnd "BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd4ShortToGnd" VALUE 0x8030206E DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd4Underload "BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd4Underload" VALUE 0x80302070 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSpeedSensorsVrEngSpdVrNShortToBatt "BSW_ku8J1939LampCodeForSpeedSensorsVrEngSpdVrNShortToBatt" VALUE 0x803020B2 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSpeedSensorsVrEngSpdVrNShortToGndOpenCircuit "BSW_ku8J1939LampCodeForSpeedSensorsVrEngSpdVrNShortToGndOpenCircuit" VALUE 0x803020B4 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSpeedSensorsVrInputSpdVrNShortToBatt "BSW_ku8J1939LampCodeForSpeedSensorsVrInputSpdVrNShortToBatt" VALUE 0x803020B6 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSpeedSensorsVrInputSpdVrNShortToGndOpenCircuit "BSW_ku8J1939LampCodeForSpeedSensorsVrInputSpdVrNShortToGndOpenCircuit" VALUE 0x803020B8 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSpeedSensorsVrOutputSpdVrNShortToBatt "BSW_ku8J1939LampCodeForSpeedSensorsVrOutputSpdVrNShortToBatt" VALUE 0x803020BA DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSpeedSensorsVrOutputSpdVrNShortToGndOpenCircuit "BSW_ku8J1939LampCodeForSpeedSensorsVrOutputSpdVrNShortToGndOpenCircuit" VALUE 0x803020BC DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSuppliesP5vSensor21OutOfHighRange "BSW_ku8J1939LampCodeForSuppliesP5vSensor21OutOfHighRange" VALUE 0x80301DDA DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSuppliesP5vSensor21OutOfLowRange "BSW_ku8J1939LampCodeForSuppliesP5vSensor21OutOfLowRange" VALUE 0x80301DDC DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSuppliesP5vSensor21ShortToBatt "BSW_ku8J1939LampCodeForSuppliesP5vSensor21ShortToBatt" VALUE 0x80301DDE DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSuppliesP5vSensor21ShortToGnd "BSW_ku8J1939LampCodeForSuppliesP5vSensor21ShortToGnd" VALUE 0x80301DE0 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSuppliesP5vSensor22OutOfHighRange "BSW_ku8J1939LampCodeForSuppliesP5vSensor22OutOfHighRange" VALUE 0x80301DE2 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSuppliesP5vSensor22OutOfLowRange "BSW_ku8J1939LampCodeForSuppliesP5vSensor22OutOfLowRange" VALUE 0x80301DE4 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSuppliesP5vSensor22ShortToBatt "BSW_ku8J1939LampCodeForSuppliesP5vSensor22ShortToBatt" VALUE 0x80301DE6 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSuppliesP5vSensor22ShortToGnd "BSW_ku8J1939LampCodeForSuppliesP5vSensor22ShortToGnd" VALUE 0x80301DE8 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSuppliesP9vSnsSup1OutOfHighRange "BSW_ku8J1939LampCodeForSuppliesP9vSnsSup1OutOfHighRange" VALUE 0x80302076 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSuppliesP9vSnsSup1OutOfLowRange "BSW_ku8J1939LampCodeForSuppliesP9vSnsSup1OutOfLowRange" VALUE 0x80302078 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSuppliesP9vSnsSup1ShortToBatt "BSW_ku8J1939LampCodeForSuppliesP9vSnsSup1ShortToBatt" VALUE 0x8030207A DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSuppliesP9vSnsSup1ShortToGnd "BSW_ku8J1939LampCodeForSuppliesP9vSnsSup1ShortToGnd" VALUE 0x8030207C DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSuppliesP9vSnsSup21OutOfHighRange "BSW_ku8J1939LampCodeForSuppliesP9vSnsSup21OutOfHighRange" VALUE 0x8030207E DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSuppliesP9vSnsSup21OutOfLowRange "BSW_ku8J1939LampCodeForSuppliesP9vSnsSup21OutOfLowRange" VALUE 0x80302080 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSuppliesP9vSnsSup21ShortToBatt "BSW_ku8J1939LampCodeForSuppliesP9vSnsSup21ShortToBatt" VALUE 0x80302082 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSuppliesP9vSnsSup21ShortToGnd "BSW_ku8J1939LampCodeForSuppliesP9vSnsSup21ShortToGnd" VALUE 0x80302084 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSuppliesP9vSnsSup22OutOfHighRange "BSW_ku8J1939LampCodeForSuppliesP9vSnsSup22OutOfHighRange" VALUE 0x80302086 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSuppliesP9vSnsSup22OutOfLowRange "BSW_ku8J1939LampCodeForSuppliesP9vSnsSup22OutOfLowRange" VALUE 0x80302088 DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSuppliesP9vSnsSup22ShortToBatt "BSW_ku8J1939LampCodeForSuppliesP9vSnsSup22ShortToBatt" VALUE 0x8030208A DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC BSW_ku8J1939LampCodeForSuppliesP9vSnsSup22ShortToGnd "BSW_ku8J1939LampCodeForSuppliesP9vSnsSup22ShortToGnd" VALUE 0x8030208C DATA_RECORD_UBYTE 16777215 F_1_p0_7 0 16777215 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_aku16AnInpScThd "analog sensor short to ground threshold." CURVE 0x800289A8 DATA_RECORD_UWORD 79.9987793 F_0v0012207031_p0_12 0 79.9987793
 /begin AXIS_DESCR FIX_AXIS NO_INPUT_QUANTITY Id_0x00 9 0 8 MAX_GRAD 100.0 FIX_AXIS_PAR_DIST 0 1 9 /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_aku16AnInpScsThd "analog sensor short to battery threshold." CURVE 0x800289BA DATA_RECORD_UWORD 79.9987793 F_0v0012207031_p0_12 0 79.9987793
 /begin AXIS_DESCR FIX_AXIS NO_INPUT_QUANTITY Id_0x00 9 0 8 MAX_GRAD 100.0 FIX_AXIS_PAR_DIST 0 1 9 /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_aku16PwmInpScThd "pwm input  short to ground threshold." CURVE 0x80028994 DATA_RECORD_UWORD 79.9987793 F_0v0012207031_p0_12 0 79.9987793
 /begin AXIS_DESCR FIX_AXIS NO_INPUT_QUANTITY Id_0x00 2 0 1 MAX_GRAD 100.0 FIX_AXIS_PAR_DIST 0 1 2 /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_aku16PwmInpScsThd "pwm input  short to battery threshold." CURVE 0x800289A2 DATA_RECORD_UWORD 79.9987793 F_0v0012207031_p0_12 0 79.9987793
 /begin AXIS_DESCR FIX_AXIS NO_INPUT_QUANTITY Id_0x00 2 0 1 MAX_GRAD 100.0 FIX_AXIS_PAR_DIST 0 1 2 /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_aku16SpdSnsrScThd "speed sensor short to ground threshold." CURVE 0x800289CC DATA_RECORD_UWORD 79.9987793 F_0v0012207031_p0_12 0 79.9987793
 /begin AXIS_DESCR FIX_AXIS NO_INPUT_QUANTITY Id_0x00 6 0 5 MAX_GRAD 100.0 FIX_AXIS_PAR_DIST 0 1 6 /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_aku16SpdSnsrScsThd "speed sensor short to battery threshold." CURVE 0x800289D8 DATA_RECORD_UWORD 79.9987793 F_0v0012207031_p0_12 0 79.9987793
 /begin AXIS_DESCR FIX_AXIS NO_INPUT_QUANTITY Id_0x00 6 0 5 MAX_GRAD 100.0 FIX_AXIS_PAR_DIST 0 1 6 /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_aku16SplyHiRngThd "supply out high range threshold." CURVE 0x80028980 DATA_RECORD_UWORD 79.9987793 F_0v0012207031_p0_12 0 79.9987793
 /begin AXIS_DESCR FIX_AXIS NO_INPUT_QUANTITY Id_0x00 5 0 4 MAX_GRAD 100.0 FIX_AXIS_PAR_DIST 0 1 5 /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_aku16SplyLoRngThd "supply  out low range threshold." CURVE 0x80028976 DATA_RECORD_UWORD 79.9987793 F_0v0012207031_p0_12 0 79.9987793
 /begin AXIS_DESCR FIX_AXIS NO_INPUT_QUANTITY Id_0x00 5 0 4 MAX_GRAD 100.0 FIX_AXIS_PAR_DIST 0 1 5 /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_aku16SplyScThd "supply  short to ground threshold." CURVE 0x8002896C DATA_RECORD_UWORD 79.9987793 F_0v0012207031_p0_12 0 79.9987793
 /begin AXIS_DESCR FIX_AXIS NO_INPUT_QUANTITY Id_0x00 5 0 4 MAX_GRAD 100.0 FIX_AXIS_PAR_DIST 0 1 5 /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_aku16SplyScsThd "supply  short to battery threshold." CURVE 0x8002898A DATA_RECORD_UWORD 79.9987793 F_0v0012207031_p0_12 0 79.9987793
 /begin AXIS_DESCR FIX_AXIS NO_INPUT_QUANTITY Id_0x00 5 0 4 MAX_GRAD 100.0 FIX_AXIS_PAR_DIST 0 1 5 /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_aku16VbatHiRngThd "VBat_P out of high range threshold." CURVE 0x80028968 DATA_RECORD_UWORD 880.201437 F_0v013431013_p0_13 0 880.201437
 /begin AXIS_DESCR FIX_AXIS NO_INPUT_QUANTITY Id_0x00 2 0 1 MAX_GRAD 100.0 FIX_AXIS_PAR_DIST 0 1 2 /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_aku16VbatLoRngThd "VBat_P out of high range  threshold." CURVE 0x80028964 DATA_RECORD_UWORD 880.201437 F_0v013431013_p0_13 0 880.201437
 /begin AXIS_DESCR FIX_AXIS NO_INPUT_QUANTITY Id_0x00 2 0 1 MAX_GRAD 100.0 FIX_AXIS_PAR_DIST 0 1 2 /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_CCVS1_RX_SA_17_LostCommDemEvePerd "Lost comm period for CCVS1_RX_SA_17." VALUE 0x800288C7 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_CCVS1_RX_SA_23_LostCommDemEvePerd "Lost comm period for CCVS1_RX_SA_23." VALUE 0x800288C8 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_CCVS1_RX_SA_33_LostCommDemEvePerd "Lost comm period for CCVS1_RX_SA_33." VALUE 0x800288C9 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_CCVS1_RX_SA_39_LostCommDemEvePerd "Lost comm period for CCVS1_RX_SA_39." VALUE 0x800288CA DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_CCVS1_RX_SA_49_LostCommDemEvePerd "Lost comm period for CCVS1_RX_SA_49." VALUE 0x800288CB DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_Ccvs1_RX_SA_00_LostCommDemEvePerd "Lost comm period for Ccvs1_RX_SA_00." VALUE 0x800288C6 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_EBC1_RX_SA_00_LostCommDemEvePerd "Lost comm period for EBC1_RX_SA_00." VALUE 0x800288CC DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_EBC1_RX_SA_11_LostCommDemEvePerd "Lost comm period for EBC1_RX_SA_11." VALUE 0x800288CD DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_EBC1_RX_SA_23_LostCommDemEvePerd "Lost comm period for EBC1_RX_SA_23." VALUE 0x800288CE DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_EBC1_RX_SA_33_LostCommDemEvePerd "Lost comm period for EBC1_RX_SA_33." VALUE 0x800288CF DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_EBC1_RX_SA_49_LostCommDemEvePerd "Lost comm period for EBC1_RX_SA_49." VALUE 0x800288D0 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_EC1_RX_SA_00_LostCommDemEvePerd "Lost comm period for EC1_RX_SA_00." VALUE 0x800288EB DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_EEC1_RX_SA_00_LostCommDemEvePerd "Lost comm period for EEC1_RX_SA_00." VALUE 0x800288EC DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_EEC2_RX_SA_00_LostCommDemEvePerd "Lost comm period for EEC2_RX_SA_00." VALUE 0x800288D1 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_EEC2_RX_SA_17_LostCommDemEvePerd "Lost comm period for EEC2_RX_SA_17." VALUE 0x800288D2 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_EEC2_RX_SA_33_LostCommDemEvePerd "Lost comm period for EEC2_RX_SA_33." VALUE 0x800288D3 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_EEC2_RX_SA_49_LostCommDemEvePerd "Lost comm period for EEC2_RX_SA_49." VALUE 0x800288D4 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_EEC3_RX_SA_00_LostCommDemEvePerd "Lost comm period for EEC3_RX_SA_00." VALUE 0x800288D5 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_ERC1_RX_SA_00_LostCommDemEvePerd "Lost comm period for ERC1_RX_SA_00." VALUE 0x800288DF DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_ERC1_RX_SA_15_LostCommDemEvePerd "Lost comm period for ERC1_RX_SA_15." VALUE 0x800288E0 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_ERC1_RX_SA_23_LostCommDemEvePerd "Lost comm period for ERC1_RX_SA_23." VALUE 0x800288E1 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_ERC1_RX_SA_33_LostCommDemEvePerd "Lost comm period for ERC1_RX_SA_33." VALUE 0x800288E2 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_ERC1_RX_SA_41_LostCommDemEvePerd "Lost comm period for ERC1_RX_SA_41." VALUE 0x800288E3 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_ERC1_RX_SA_49_LostCommDemEvePerd "Lost comm period for ERC1_RX_SA_49." VALUE 0x800288E4 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_ET1_RX_SA_00_LostCommDemEvePerd "Lost comm period for ET1_RX_SA_00." VALUE 0x800288ED DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_LFE1_RX_SA_00_LostCommDemEvePerd "Lost comm period for LFE1_RX_SA_00." VALUE 0x800288EE DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_PTODE_RX_SA_23_LostCommDemEvePerd "Lost comm period for PTODE_RX_SA_23." VALUE 0x800288D6 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_PTODE_RX_SA_33_LostCommDemEvePerd "Lost comm period for PTODE_RX_SA_33." VALUE 0x800288D7 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_PTODE_RX_SA_49_LostCommDemEvePerd "Lost comm period for PTODE_RX_SA_49." VALUE 0x800288D8 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_RC_RX_SA_15_LostCommDemEvePerd "Lost comm period for RC_RX_SA_15." VALUE 0x800288EF DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_RC_RX_SA_41_LostCommDemEvePerd "Lost comm period for RC_RX_SA_41." VALUE 0x800288F0 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_RxMsg10Can1_LostCommDemEvePerd "Lost comm period for RxMsg10Can1." VALUE 0x800288FA DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_RxMsg10Can2_LostCommDemEvePerd "Lost comm period for RxMsg10Can2." VALUE 0x80028909 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_RxMsg11Can1_LostCommDemEvePerd "Lost comm period for RxMsg11Can1." VALUE 0x800288FB DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_RxMsg11Can2_LostCommDemEvePerd "Lost comm period for RxMsg11Can2." VALUE 0x8002890A DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_RxMsg12Can1_LostCommDemEvePerd "Lost comm period for RxMsg12Can1." VALUE 0x800288FC DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_RxMsg12Can2_LostCommDemEvePerd "Lost comm period for RxMsg12Can2." VALUE 0x8002890B DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_RxMsg13Can1_LostCommDemEvePerd "Lost comm period for RxMsg13Can1." VALUE 0x800288FD DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_RxMsg13Can2_LostCommDemEvePerd "Lost comm period for RxMsg13Can2." VALUE 0x8002890C DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_RxMsg14Can1_LostCommDemEvePerd "Lost comm period for RxMsg14Can1." VALUE 0x800288FE DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_RxMsg14Can2_LostCommDemEvePerd "Lost comm period for RxMsg14Can2." VALUE 0x8002890D DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_RxMsg15Can1_LostCommDemEvePerd "Lost comm period for RxMsg15Can1." VALUE 0x800288FF DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_RxMsg15Can2_LostCommDemEvePerd "Lost comm period for RxMsg15Can2." VALUE 0x8002890E DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_RxMsg1Can1_LostCommDemEvePerd "Lost comm period for RxMsg1Can1." VALUE 0x800288F1 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_RxMsg1Can2_LostCommDemEvePerd "Lost comm period for RxMsg1Can2." VALUE 0x80028900 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_RxMsg2Can1_LostCommDemEvePerd "Lost comm period for RxMsg2Can1." VALUE 0x800288F2 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_RxMsg2Can2_LostCommDemEvePerd "Lost comm period for RxMsg2Can2." VALUE 0x80028901 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_RxMsg3Can1_LostCommDemEvePerd "Lost comm period for RxMsg3Can1." VALUE 0x800288F3 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_RxMsg3Can2_LostCommDemEvePerd "Lost comm period for RxMsg3Can2." VALUE 0x80028902 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_RxMsg4Can1_LostCommDemEvePerd "Lost comm period for RxMsg4Can1." VALUE 0x800288F4 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_RxMsg4Can2_LostCommDemEvePerd "Lost comm period for RxMsg4Can2." VALUE 0x80028903 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_RxMsg5Can1_LostCommDemEvePerd "Lost comm period for RxMsg5Can1." VALUE 0x800288F5 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_RxMsg5Can2_LostCommDemEvePerd "Lost comm period for RxMsg5Can2." VALUE 0x80028904 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_RxMsg6Can1_LostCommDemEvePerd "Lost comm period for RxMsg6Can1." VALUE 0x800288F6 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_RxMsg6Can2_LostCommDemEvePerd "Lost comm period for RxMsg6Can2." VALUE 0x80028905 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_RxMsg7Can1_LostCommDemEvePerd "Lost comm period for RxMsg7Can1." VALUE 0x800288F7 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_RxMsg7Can2_LostCommDemEvePerd "Lost comm period for RxMsg7Can2." VALUE 0x80028906 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_RxMsg8Can1_LostCommDemEvePerd "Lost comm period for RxMsg8Can1." VALUE 0x800288F8 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_RxMsg8Can2_LostCommDemEvePerd "Lost comm period for RxMsg8Can2." VALUE 0x80028907 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_RxMsg9Can1_LostCommDemEvePerd "Lost comm period for RxMsg9Can1." VALUE 0x800288F9 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_RxMsg9Can2_LostCommDemEvePerd "Lost comm period for RxMsg9Can2." VALUE 0x80028908 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_TC1_RX_SA_05_LostCommDemEvePerd "Lost comm period for TC1_RX_SA_05." VALUE 0x800288D9 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_TC1_RX_SA_06_LostCommDemEvePerd "Lost comm period for TC1_RX_SA_06." VALUE 0x800288DA DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_TC1_RX_SA_23_LostCommDemEvePerd "Lost comm period for TC1_RX_SA_23." VALUE 0x800288DB DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_TC1_RX_SA_33_LostCommDemEvePerd "Lost comm period for TC1_RX_SA_33." VALUE 0x800288DC DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_TC1_RX_SA_42_LostCommDemEvePerd "Lost comm period for TC1_RX_SA_42." VALUE 0x800288DD DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_TC1_RX_SA_49_LostCommDemEvePerd "Lost comm period for TC1_RX_SA_49." VALUE 0x800288DE DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_TSC1_RX_SA_00_LostCommDemEvePerd "Lost comm period for TSC1_RX_SA_00." VALUE 0x800288E5 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_TSC1_RX_SA_11_LostCommDemEvePerd "Lost comm period for TSC1_RX_SA_11." VALUE 0x800288E6 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_TSC1_RX_SA_17_LostCommDemEvePerd "Lost comm period for TSC1_RX_SA_17." VALUE 0x800288E7 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_TSC1_RX_SA_33_LostCommDemEvePerd "Lost comm period for TSC1_RX_SA_33." VALUE 0x800288E8 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_TSC1_RX_SA_39_LostCommDemEvePerd "Lost comm period for TSC1_RX_SA_39." VALUE 0x800288E9 DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_kbJ1939_TSC1_RX_SA_42_LostCommDemEvePerd "Lost comm period for TSC1_RX_SA_42." VALUE 0x800288EA DATA_RECORD_UWORD 65535 I_5 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_ku16PwmInpMaxDuty "DIAGC_ku16PwmInpMaxDuty" VALUE 0x800289A0 DATA_RECORD_UWORD 16384 F_1_p0_7 0 16384 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_ku16PwmInpMinDuty "DIAGC_ku16PwmInpMinDuty" VALUE 0x8002899E DATA_RECORD_UWORD 16384 F_1_p0_7 0 16384 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_ku16SplyHiRngThdP5V1 "P5V1 supply out high range threshold." VALUE 0x80028986 DATA_RECORD_UWORD 160.0366011 F_0v002442002_p0_14 0 160.0366011 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_ku16SplyHiRngThdP5V2 "P5V2 supply out high range threshold." VALUE 0x80028988 DATA_RECORD_UWORD 160.0366011 F_0v002442002_p0_14 0 160.0366011 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_ku16SplyHiRngThdP9V1 "P9V1 supply out high range threshold." VALUE 0x80028980 DATA_RECORD_UWORD 287.6607708 F_0v004389422_p0_15 0 287.6607708 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_ku16SplyHiRngThdP9V2 "P9V2 supply out high range threshold." VALUE 0x80028982 DATA_RECORD_UWORD 287.6607708 F_0v004389422_p0_15 0 287.6607708 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_ku16SplyHiRngThdP9V3 "P9V3 supply out high range threshold." VALUE 0x80028984 DATA_RECORD_UWORD 287.6607708 F_0v004389422_p0_15 0 287.6607708 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_ku16SplyLoRngThdP5V1 "P5V1 supply out high range threshold." VALUE 0x8002897C DATA_RECORD_UWORD 160.0366011 F_0v002442002_p0_14 0 160.0366011 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_ku16SplyLoRngThdP5V2 "P5V2 supply out high range threshold." VALUE 0x8002897E DATA_RECORD_UWORD 160.0366011 F_0v002442002_p0_14 0 160.0366011 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_ku16SplyLoRngThdP9V1 "P9V1 supply out high range threshold." VALUE 0x80028976 DATA_RECORD_UWORD 287.6607708 F_0v004389422_p0_15 0 287.6607708 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_ku16SplyLoRngThdP9V2 "P9V2 supply out high range threshold." VALUE 0x80028978 DATA_RECORD_UWORD 287.6607708 F_0v004389422_p0_15 0 287.6607708 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_ku16SplyLoRngThdP9V3 "P9V3 supply out high range threshold." VALUE 0x8002897A DATA_RECORD_UWORD 287.6607708 F_0v004389422_p0_15 0 287.6607708 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_ku16SplyMaxDuty "DIAGC_ku16SplyMaxDuty" VALUE 0x8002899C DATA_RECORD_UWORD 16384 F_1_p0_7 0 16384 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_ku16SplyMinDuty "DIAGC_ku16SplyMinDuty" VALUE 0x8002899A DATA_RECORD_UWORD 16384 F_1_p0_7 0 16384 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_ku16SplyScThdP5V1 "P5V1 supply out high range threshold." VALUE 0x80028972 DATA_RECORD_UWORD 160.0366011 F_0v002442002_p0_14 0 160.0366011 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_ku16SplyScThdP5V2 "P5V2 supply out high range threshold." VALUE 0x80028974 DATA_RECORD_UWORD 160.0366011 F_0v002442002_p0_14 0 160.0366011 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_ku16SplyScThdP9V1 "P9V1 supply out high range threshold." VALUE 0x8002896C DATA_RECORD_UWORD 287.6607708 F_0v004389422_p0_15 0 287.6607708 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_ku16SplyScThdP9V2 "P9V2 supply out high range threshold." VALUE 0x8002896E DATA_RECORD_UWORD 287.6607708 F_0v004389422_p0_15 0 287.6607708 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_ku16SplyScThdP9V3 "P9V3 supply out high range threshold." VALUE 0x80028970 DATA_RECORD_UWORD 287.6607708 F_0v004389422_p0_15 0 287.6607708 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_ku16SplyScsThdP5V1 "P5V1 supply out high range threshold." VALUE 0x80028990 DATA_RECORD_UWORD 160.0366011 F_0v002442002_p0_14 0 160.0366011 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_ku16SplyScsThdP5V2 "P5V2 supply out high range threshold." VALUE 0x80028992 DATA_RECORD_UWORD 160.0366011 F_0v002442002_p0_14 0 160.0366011 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_ku16SplyScsThdP9V1 "P9V1 supply out high range threshold." VALUE 0x8002898A DATA_RECORD_UWORD 287.6607708 F_0v004389422_p0_15 0 287.6607708 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_ku16SplyScsThdP9V2 "P9V2 supply out high range threshold." VALUE 0x8002898C DATA_RECORD_UWORD 287.6607708 F_0v004389422_p0_15 0 287.6607708 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_ku16SplyScsThdP9V3 "P9V3 supply out high range threshold." VALUE 0x8002898E DATA_RECORD_UWORD 287.6607708 F_0v004389422_p0_15 0 287.6607708 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_ku16VbatExtremeHiThd "VBat_P out of high range  threshold." VALUE 0x8002895A DATA_RECORD_UWORD 880.201437 F_0v013431013_p0_13 0 880.201437 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_ku16VbatPyThd "VBat_P out of high range  threshold." VALUE 0x800288C0 DATA_RECORD_UWORD 880.201437 F_0v013431013_p0_13 0 880.201437 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_ku8LostCommDiagDecStep "Lost commucation counter." VALUE 0x800288C2 DATA_RECORD_UBYTE 255 F_1_p0_7 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_ku8LostCommDiagIncStep "Lost commucation counter." VALUE 0x800288C3 DATA_RECORD_UBYTE 255 F_1_p0_7 0 255 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_ku8LostCommDiagMaxVal "Lost commucation counter." VALUE 0x800288C5 DATA_RECORD_UBYTE 0 F_1_p0_7 0 0 /end CHARACTERISTIC
/begin CHARACTERISTIC DIAGC_ku8LostCommDiagThd "Lost commucation counter." VALUE 0x800288C4 DATA_RECORD_UBYTE 0 F_1_p0_7 0 0 /end CHARACTERISTIC
/begin CHARACTERISTIC J1939_ku32Tsc1Sa03MsgId "J1939_ku32Tsc1Sa03MsgId" VALUE 0x80028A30 DATA_RECORD_ULONG 4294967295 F_1_p0_7 0 4294967295 /end CHARACTERISTIC
/begin CHARACTERISTIC MAIN_f32Trim2Nvm_def "NvM test" VALUE 0x800280C0 DATA_RECORD_FLOAT32_IEEE 4294967295 I_5 -2147483648 2147483647 /end CHARACTERISTIC
/begin CHARACTERISTIC MAIN_s32Trim3Nvm_def "NvM test" VALUE 0x800280AC DATA_RECORD_SLONG 4294967295 I_5 -2147483648 2147483647 /end CHARACTERISTIC
/begin CHARACTERISTIC MAIN_u32Trim1Nvm_def "NvM test" VALUE 0x800280BC DATA_RECORD_ULONG 4294967295 I_5 0 4294967295 /end CHARACTERISTIC
/begin CHARACTERISTIC MAIN_u8FaultNvm_def "NvM test" CURVE 0x800280B0 DATA_RECORD_UBYTE 255 I_5 0 255
 /begin AXIS_DESCR FIX_AXIS NO_INPUT_QUANTITY Id_0x00 10 0 9 MAX_GRAD 100.0 FIX_AXIS_PAR_DIST 0 1 10 /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC PWD_kudtTout_ENG_SPD_HALL_PWM "Initial value of timeout of DF PLUG PWM channel" VALUE 0x80028A1C DATA_RECORD_ULONG 4.294967295E+012 F_1000_p0_18 0 4.294967295E+012 /end CHARACTERISTIC
/begin CHARACTERISTIC PWD_kudtTout_ENG_SPD_VR_PWM "Initial value of timeout of DF PLUG PWM channel" VALUE 0x80028A10 DATA_RECORD_ULONG 4.294967295E+012 F_1000_p0_18 0 4.294967295E+012 /end CHARACTERISTIC
/begin CHARACTERISTIC PWD_kudtTout_INPUT_SPD_HALL_PWM "Initial value of timeout of DF PLUG PWM channel" VALUE 0x80028A18 DATA_RECORD_ULONG 4.294967295E+012 F_1000_p0_18 0 4.294967295E+012 /end CHARACTERISTIC
/begin CHARACTERISTIC PWD_kudtTout_INPUT_SPD_VR_PWM "Initial value of timeout of DF PLUG PWM channel" VALUE 0x80028A0C DATA_RECORD_ULONG 4.294967295E+012 F_1000_p0_18 0 4.294967295E+012 /end CHARACTERISTIC
/begin CHARACTERISTIC PWD_kudtTout_OUTPUT_SPD_HALL_PWM "Initial value of timeout of DF PLUG PWM channel" VALUE 0x80028A14 DATA_RECORD_ULONG 4.294967295E+012 F_1000_p0_18 0 4.294967295E+012 /end CHARACTERISTIC
/begin CHARACTERISTIC PWD_kudtTout_OUTPUT_SPD_VR_PWM "Initial value of timeout of DF PLUG PWM channel" VALUE 0x80028A08 DATA_RECORD_ULONG 4.294967295E+012 F_1000_p0_18 0 4.294967295E+012 /end CHARACTERISTIC
/begin CHARACTERISTIC PWD_kudtTout_PWM_IN_1 "Initial value of timeout of DF PLUG PWM channel" VALUE 0x80028A28 DATA_RECORD_ULONG 4.294967295E+012 F_1000_p0_18 0 4.294967295E+012 /end CHARACTERISTIC
/begin CHARACTERISTIC PWD_kudtTout_PWM_IN_2 "Initial value of timeout of DF PLUG PWM channel" VALUE 0x80028A24 DATA_RECORD_ULONG 4.294967295E+012 F_1000_p0_18 0 4.294967295E+012 /end CHARACTERISTIC
/begin CHARACTERISTIC PWD_kudtTout_PWM_IN_3 "Initial value of timeout of DF PLUG PWM channel" VALUE 0x80028A20 DATA_RECORD_ULONG 4.294967295E+012 F_1000_p0_18 0 4.294967295E+012 /end CHARACTERISTIC
/begin MEASUREMENT BSW_ku32SwVers "basic software version." ULONG F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x80080010 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT BSW_u8RstCnt "BSW_u8RstCnt" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600004CC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt "Lost commucation counter." UBYTE F_1_p0_7 1 2 0 0 MATRIX_DIM 1 67 1 ECU_ADDRESS 0x60006798 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[0] "DIAGC_au8ComJ1939MsgRxdCnt[0]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60006798 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[10] "DIAGC_au8ComJ1939MsgRxdCnt[10]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067A2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[11] "DIAGC_au8ComJ1939MsgRxdCnt[11]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067A3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[12] "DIAGC_au8ComJ1939MsgRxdCnt[12]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067A4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[13] "DIAGC_au8ComJ1939MsgRxdCnt[13]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067A5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[14] "DIAGC_au8ComJ1939MsgRxdCnt[14]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067A6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[15] "DIAGC_au8ComJ1939MsgRxdCnt[15]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067A7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[16] "DIAGC_au8ComJ1939MsgRxdCnt[16]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067A8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[17] "DIAGC_au8ComJ1939MsgRxdCnt[17]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067A9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[18] "DIAGC_au8ComJ1939MsgRxdCnt[18]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067AA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[19] "DIAGC_au8ComJ1939MsgRxdCnt[19]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067AB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[1] "DIAGC_au8ComJ1939MsgRxdCnt[1]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60006799 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[20] "DIAGC_au8ComJ1939MsgRxdCnt[20]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[21] "DIAGC_au8ComJ1939MsgRxdCnt[21]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067AD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[22] "DIAGC_au8ComJ1939MsgRxdCnt[22]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067AE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[23] "DIAGC_au8ComJ1939MsgRxdCnt[23]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067AF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[24] "DIAGC_au8ComJ1939MsgRxdCnt[24]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067B0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[25] "DIAGC_au8ComJ1939MsgRxdCnt[25]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067B1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[26] "DIAGC_au8ComJ1939MsgRxdCnt[26]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067B2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[27] "DIAGC_au8ComJ1939MsgRxdCnt[27]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067B3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[28] "DIAGC_au8ComJ1939MsgRxdCnt[28]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067B4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[29] "DIAGC_au8ComJ1939MsgRxdCnt[29]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067B5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[2] "DIAGC_au8ComJ1939MsgRxdCnt[2]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000679A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[30] "DIAGC_au8ComJ1939MsgRxdCnt[30]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067B6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[31] "DIAGC_au8ComJ1939MsgRxdCnt[31]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067B7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[32] "DIAGC_au8ComJ1939MsgRxdCnt[32]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067B8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[33] "DIAGC_au8ComJ1939MsgRxdCnt[33]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067B9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[34] "DIAGC_au8ComJ1939MsgRxdCnt[34]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067BA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[35] "DIAGC_au8ComJ1939MsgRxdCnt[35]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067BB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[36] "DIAGC_au8ComJ1939MsgRxdCnt[36]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067BC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[37] "DIAGC_au8ComJ1939MsgRxdCnt[37]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067BD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[38] "DIAGC_au8ComJ1939MsgRxdCnt[38]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067BE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[39] "DIAGC_au8ComJ1939MsgRxdCnt[39]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067BF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[3] "DIAGC_au8ComJ1939MsgRxdCnt[3]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000679B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[40] "DIAGC_au8ComJ1939MsgRxdCnt[40]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067C0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[41] "DIAGC_au8ComJ1939MsgRxdCnt[41]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067C1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[42] "DIAGC_au8ComJ1939MsgRxdCnt[42]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067C2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[43] "DIAGC_au8ComJ1939MsgRxdCnt[43]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067C3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[44] "DIAGC_au8ComJ1939MsgRxdCnt[44]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067C4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[45] "DIAGC_au8ComJ1939MsgRxdCnt[45]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067C5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[46] "DIAGC_au8ComJ1939MsgRxdCnt[46]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067C6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[47] "DIAGC_au8ComJ1939MsgRxdCnt[47]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067C7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[48] "DIAGC_au8ComJ1939MsgRxdCnt[48]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067C8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[49] "DIAGC_au8ComJ1939MsgRxdCnt[49]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067C9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[4] "DIAGC_au8ComJ1939MsgRxdCnt[4]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000679C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[50] "DIAGC_au8ComJ1939MsgRxdCnt[50]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067CA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[51] "DIAGC_au8ComJ1939MsgRxdCnt[51]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067CB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[52] "DIAGC_au8ComJ1939MsgRxdCnt[52]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067CC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[53] "DIAGC_au8ComJ1939MsgRxdCnt[53]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067CD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[54] "DIAGC_au8ComJ1939MsgRxdCnt[54]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067CE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[55] "DIAGC_au8ComJ1939MsgRxdCnt[55]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067CF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[56] "DIAGC_au8ComJ1939MsgRxdCnt[56]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067D0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[57] "DIAGC_au8ComJ1939MsgRxdCnt[57]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067D1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[58] "DIAGC_au8ComJ1939MsgRxdCnt[58]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067D2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[59] "DIAGC_au8ComJ1939MsgRxdCnt[59]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067D3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[5] "DIAGC_au8ComJ1939MsgRxdCnt[5]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000679D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[60] "DIAGC_au8ComJ1939MsgRxdCnt[60]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067D4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[61] "DIAGC_au8ComJ1939MsgRxdCnt[61]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067D5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[62] "DIAGC_au8ComJ1939MsgRxdCnt[62]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067D6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[63] "DIAGC_au8ComJ1939MsgRxdCnt[63]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067D7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[64] "DIAGC_au8ComJ1939MsgRxdCnt[64]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067D8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[65] "DIAGC_au8ComJ1939MsgRxdCnt[65]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067D9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[66] "DIAGC_au8ComJ1939MsgRxdCnt[66]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067DA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[6] "DIAGC_au8ComJ1939MsgRxdCnt[6]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000679E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[7] "DIAGC_au8ComJ1939MsgRxdCnt[7]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000679F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[8] "DIAGC_au8ComJ1939MsgRxdCnt[8]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067A0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8ComJ1939MsgRxdCnt[9] "DIAGC_au8ComJ1939MsgRxdCnt[9]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600067A1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts "Current diagnostic state." UBYTE F_1_p0_7 1 2 0 0 MATRIX_DIM 1 364 1 ECU_ADDRESS 0x6000874C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[0] "DIAGC_au8EveSts[0]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000874C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[100] "DIAGC_au8EveSts[100]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087B0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[101] "DIAGC_au8EveSts[101]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087B1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[102] "DIAGC_au8EveSts[102]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087B2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[103] "DIAGC_au8EveSts[103]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087B3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[104] "DIAGC_au8EveSts[104]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087B4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[105] "DIAGC_au8EveSts[105]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087B5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[106] "DIAGC_au8EveSts[106]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087B6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[107] "DIAGC_au8EveSts[107]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087B7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[108] "DIAGC_au8EveSts[108]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087B8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[109] "DIAGC_au8EveSts[109]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087B9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[10] "DIAGC_au8EveSts[10]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008756 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[110] "DIAGC_au8EveSts[110]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087BA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[111] "DIAGC_au8EveSts[111]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087BB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[112] "DIAGC_au8EveSts[112]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087BC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[113] "DIAGC_au8EveSts[113]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087BD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[114] "DIAGC_au8EveSts[114]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087BE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[115] "DIAGC_au8EveSts[115]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087BF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[116] "DIAGC_au8EveSts[116]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087C0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[117] "DIAGC_au8EveSts[117]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087C1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[118] "DIAGC_au8EveSts[118]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087C2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[119] "DIAGC_au8EveSts[119]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087C3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[11] "DIAGC_au8EveSts[11]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008757 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[120] "DIAGC_au8EveSts[120]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087C4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[121] "DIAGC_au8EveSts[121]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087C5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[122] "DIAGC_au8EveSts[122]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087C6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[123] "DIAGC_au8EveSts[123]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087C7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[124] "DIAGC_au8EveSts[124]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087C8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[125] "DIAGC_au8EveSts[125]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087C9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[126] "DIAGC_au8EveSts[126]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087CA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[127] "DIAGC_au8EveSts[127]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087CB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[128] "DIAGC_au8EveSts[128]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087CC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[129] "DIAGC_au8EveSts[129]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087CD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[12] "DIAGC_au8EveSts[12]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008758 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[130] "DIAGC_au8EveSts[130]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087CE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[131] "DIAGC_au8EveSts[131]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087CF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[132] "DIAGC_au8EveSts[132]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087D0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[133] "DIAGC_au8EveSts[133]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087D1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[134] "DIAGC_au8EveSts[134]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087D2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[135] "DIAGC_au8EveSts[135]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087D3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[136] "DIAGC_au8EveSts[136]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087D4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[137] "DIAGC_au8EveSts[137]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087D5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[138] "DIAGC_au8EveSts[138]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087D6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[139] "DIAGC_au8EveSts[139]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087D7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[13] "DIAGC_au8EveSts[13]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008759 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[140] "DIAGC_au8EveSts[140]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087D8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[141] "DIAGC_au8EveSts[141]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087D9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[142] "DIAGC_au8EveSts[142]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087DA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[143] "DIAGC_au8EveSts[143]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087DB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[144] "DIAGC_au8EveSts[144]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087DC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[145] "DIAGC_au8EveSts[145]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087DD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[146] "DIAGC_au8EveSts[146]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087DE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[147] "DIAGC_au8EveSts[147]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087DF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[148] "DIAGC_au8EveSts[148]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087E0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[149] "DIAGC_au8EveSts[149]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087E1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[14] "DIAGC_au8EveSts[14]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000875A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[150] "DIAGC_au8EveSts[150]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087E2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[151] "DIAGC_au8EveSts[151]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087E3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[152] "DIAGC_au8EveSts[152]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087E4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[153] "DIAGC_au8EveSts[153]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087E5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[154] "DIAGC_au8EveSts[154]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087E6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[155] "DIAGC_au8EveSts[155]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087E7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[156] "DIAGC_au8EveSts[156]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087E8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[157] "DIAGC_au8EveSts[157]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087E9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[158] "DIAGC_au8EveSts[158]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087EA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[159] "DIAGC_au8EveSts[159]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087EB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[15] "DIAGC_au8EveSts[15]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000875B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[160] "DIAGC_au8EveSts[160]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087EC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[161] "DIAGC_au8EveSts[161]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087ED READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[162] "DIAGC_au8EveSts[162]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087EE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[163] "DIAGC_au8EveSts[163]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087EF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[164] "DIAGC_au8EveSts[164]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087F0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[165] "DIAGC_au8EveSts[165]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087F1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[166] "DIAGC_au8EveSts[166]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087F2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[167] "DIAGC_au8EveSts[167]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087F3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[168] "DIAGC_au8EveSts[168]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087F4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[169] "DIAGC_au8EveSts[169]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087F5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[16] "DIAGC_au8EveSts[16]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000875C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[170] "DIAGC_au8EveSts[170]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087F6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[171] "DIAGC_au8EveSts[171]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087F7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[172] "DIAGC_au8EveSts[172]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087F8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[173] "DIAGC_au8EveSts[173]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087F9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[174] "DIAGC_au8EveSts[174]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087FA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[175] "DIAGC_au8EveSts[175]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087FB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[176] "DIAGC_au8EveSts[176]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087FC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[177] "DIAGC_au8EveSts[177]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087FD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[178] "DIAGC_au8EveSts[178]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087FE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[179] "DIAGC_au8EveSts[179]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087FF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[17] "DIAGC_au8EveSts[17]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000875D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[180] "DIAGC_au8EveSts[180]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008800 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[181] "DIAGC_au8EveSts[181]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008801 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[182] "DIAGC_au8EveSts[182]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008802 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[183] "DIAGC_au8EveSts[183]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008803 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[184] "DIAGC_au8EveSts[184]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008804 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[185] "DIAGC_au8EveSts[185]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008805 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[186] "DIAGC_au8EveSts[186]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008806 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[187] "DIAGC_au8EveSts[187]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008807 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[188] "DIAGC_au8EveSts[188]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008808 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[189] "DIAGC_au8EveSts[189]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008809 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[18] "DIAGC_au8EveSts[18]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000875E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[190] "DIAGC_au8EveSts[190]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000880A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[191] "DIAGC_au8EveSts[191]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000880B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[192] "DIAGC_au8EveSts[192]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000880C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[193] "DIAGC_au8EveSts[193]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000880D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[194] "DIAGC_au8EveSts[194]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000880E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[195] "DIAGC_au8EveSts[195]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000880F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[196] "DIAGC_au8EveSts[196]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008810 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[197] "DIAGC_au8EveSts[197]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008811 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[198] "DIAGC_au8EveSts[198]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008812 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[199] "DIAGC_au8EveSts[199]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008813 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[19] "DIAGC_au8EveSts[19]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000875F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[1] "DIAGC_au8EveSts[1]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000874D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[200] "DIAGC_au8EveSts[200]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008814 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[201] "DIAGC_au8EveSts[201]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008815 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[202] "DIAGC_au8EveSts[202]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008816 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[203] "DIAGC_au8EveSts[203]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008817 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[204] "DIAGC_au8EveSts[204]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008818 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[205] "DIAGC_au8EveSts[205]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008819 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[206] "DIAGC_au8EveSts[206]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000881A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[207] "DIAGC_au8EveSts[207]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000881B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[208] "DIAGC_au8EveSts[208]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000881C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[209] "DIAGC_au8EveSts[209]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000881D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[20] "DIAGC_au8EveSts[20]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008760 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[210] "DIAGC_au8EveSts[210]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000881E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[211] "DIAGC_au8EveSts[211]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000881F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[212] "DIAGC_au8EveSts[212]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008820 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[213] "DIAGC_au8EveSts[213]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008821 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[214] "DIAGC_au8EveSts[214]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008822 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[215] "DIAGC_au8EveSts[215]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008823 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[216] "DIAGC_au8EveSts[216]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008824 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[217] "DIAGC_au8EveSts[217]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008825 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[218] "DIAGC_au8EveSts[218]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008826 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[219] "DIAGC_au8EveSts[219]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008827 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[21] "DIAGC_au8EveSts[21]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008761 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[220] "DIAGC_au8EveSts[220]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008828 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[221] "DIAGC_au8EveSts[221]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008829 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[222] "DIAGC_au8EveSts[222]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000882A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[223] "DIAGC_au8EveSts[223]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000882B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[224] "DIAGC_au8EveSts[224]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000882C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[225] "DIAGC_au8EveSts[225]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000882D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[226] "DIAGC_au8EveSts[226]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000882E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[227] "DIAGC_au8EveSts[227]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000882F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[228] "DIAGC_au8EveSts[228]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008830 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[229] "DIAGC_au8EveSts[229]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008831 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[22] "DIAGC_au8EveSts[22]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008762 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[230] "DIAGC_au8EveSts[230]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008832 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[231] "DIAGC_au8EveSts[231]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008833 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[232] "DIAGC_au8EveSts[232]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008834 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[233] "DIAGC_au8EveSts[233]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008835 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[234] "DIAGC_au8EveSts[234]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008836 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[235] "DIAGC_au8EveSts[235]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008837 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[236] "DIAGC_au8EveSts[236]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008838 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[237] "DIAGC_au8EveSts[237]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008839 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[238] "DIAGC_au8EveSts[238]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000883A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[239] "DIAGC_au8EveSts[239]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000883B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[23] "DIAGC_au8EveSts[23]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008763 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[240] "DIAGC_au8EveSts[240]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000883C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[241] "DIAGC_au8EveSts[241]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000883D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[242] "DIAGC_au8EveSts[242]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000883E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[243] "DIAGC_au8EveSts[243]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000883F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[244] "DIAGC_au8EveSts[244]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008840 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[245] "DIAGC_au8EveSts[245]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008841 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[246] "DIAGC_au8EveSts[246]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008842 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[247] "DIAGC_au8EveSts[247]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008843 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[248] "DIAGC_au8EveSts[248]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008844 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[249] "DIAGC_au8EveSts[249]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008845 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[24] "DIAGC_au8EveSts[24]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008764 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[250] "DIAGC_au8EveSts[250]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008846 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[251] "DIAGC_au8EveSts[251]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008847 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[252] "DIAGC_au8EveSts[252]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008848 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[253] "DIAGC_au8EveSts[253]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008849 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[254] "DIAGC_au8EveSts[254]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000884A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[255] "DIAGC_au8EveSts[255]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000884B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[256] "DIAGC_au8EveSts[256]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000884C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[257] "DIAGC_au8EveSts[257]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000884D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[258] "DIAGC_au8EveSts[258]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000884E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[259] "DIAGC_au8EveSts[259]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000884F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[25] "DIAGC_au8EveSts[25]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008765 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[260] "DIAGC_au8EveSts[260]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008850 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[261] "DIAGC_au8EveSts[261]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008851 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[262] "DIAGC_au8EveSts[262]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008852 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[263] "DIAGC_au8EveSts[263]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008853 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[264] "DIAGC_au8EveSts[264]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008854 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[265] "DIAGC_au8EveSts[265]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008855 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[266] "DIAGC_au8EveSts[266]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008856 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[267] "DIAGC_au8EveSts[267]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008857 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[268] "DIAGC_au8EveSts[268]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008858 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[269] "DIAGC_au8EveSts[269]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008859 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[26] "DIAGC_au8EveSts[26]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008766 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[270] "DIAGC_au8EveSts[270]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000885A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[271] "DIAGC_au8EveSts[271]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000885B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[272] "DIAGC_au8EveSts[272]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000885C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[273] "DIAGC_au8EveSts[273]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000885D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[274] "DIAGC_au8EveSts[274]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000885E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[275] "DIAGC_au8EveSts[275]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000885F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[276] "DIAGC_au8EveSts[276]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008860 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[277] "DIAGC_au8EveSts[277]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008861 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[278] "DIAGC_au8EveSts[278]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008862 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[279] "DIAGC_au8EveSts[279]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008863 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[27] "DIAGC_au8EveSts[27]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008767 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[280] "DIAGC_au8EveSts[280]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008864 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[281] "DIAGC_au8EveSts[281]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008865 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[282] "DIAGC_au8EveSts[282]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008866 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[283] "DIAGC_au8EveSts[283]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008867 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[284] "DIAGC_au8EveSts[284]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008868 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[285] "DIAGC_au8EveSts[285]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008869 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[286] "DIAGC_au8EveSts[286]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000886A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[287] "DIAGC_au8EveSts[287]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000886B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[288] "DIAGC_au8EveSts[288]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000886C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[289] "DIAGC_au8EveSts[289]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000886D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[28] "DIAGC_au8EveSts[28]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008768 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[290] "DIAGC_au8EveSts[290]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000886E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[291] "DIAGC_au8EveSts[291]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000886F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[292] "DIAGC_au8EveSts[292]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008870 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[293] "DIAGC_au8EveSts[293]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008871 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[294] "DIAGC_au8EveSts[294]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008872 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[295] "DIAGC_au8EveSts[295]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008873 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[296] "DIAGC_au8EveSts[296]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008874 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[297] "DIAGC_au8EveSts[297]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008875 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[298] "DIAGC_au8EveSts[298]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008876 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[299] "DIAGC_au8EveSts[299]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008877 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[29] "DIAGC_au8EveSts[29]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008769 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[2] "DIAGC_au8EveSts[2]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000874E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[300] "DIAGC_au8EveSts[300]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008878 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[301] "DIAGC_au8EveSts[301]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008879 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[302] "DIAGC_au8EveSts[302]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000887A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[303] "DIAGC_au8EveSts[303]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000887B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[304] "DIAGC_au8EveSts[304]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000887C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[305] "DIAGC_au8EveSts[305]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000887D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[306] "DIAGC_au8EveSts[306]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000887E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[307] "DIAGC_au8EveSts[307]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000887F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[308] "DIAGC_au8EveSts[308]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008880 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[309] "DIAGC_au8EveSts[309]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008881 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[30] "DIAGC_au8EveSts[30]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000876A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[310] "DIAGC_au8EveSts[310]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008882 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[311] "DIAGC_au8EveSts[311]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008883 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[312] "DIAGC_au8EveSts[312]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008884 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[313] "DIAGC_au8EveSts[313]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008885 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[314] "DIAGC_au8EveSts[314]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008886 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[315] "DIAGC_au8EveSts[315]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008887 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[316] "DIAGC_au8EveSts[316]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008888 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[317] "DIAGC_au8EveSts[317]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008889 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[318] "DIAGC_au8EveSts[318]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000888A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[319] "DIAGC_au8EveSts[319]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000888B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[31] "DIAGC_au8EveSts[31]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000876B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[320] "DIAGC_au8EveSts[320]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000888C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[321] "DIAGC_au8EveSts[321]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000888D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[322] "DIAGC_au8EveSts[322]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000888E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[323] "DIAGC_au8EveSts[323]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000888F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[324] "DIAGC_au8EveSts[324]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008890 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[325] "DIAGC_au8EveSts[325]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008891 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[326] "DIAGC_au8EveSts[326]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008892 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[327] "DIAGC_au8EveSts[327]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008893 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[328] "DIAGC_au8EveSts[328]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008894 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[329] "DIAGC_au8EveSts[329]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008895 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[32] "DIAGC_au8EveSts[32]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000876C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[330] "DIAGC_au8EveSts[330]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008896 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[331] "DIAGC_au8EveSts[331]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008897 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[332] "DIAGC_au8EveSts[332]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008898 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[333] "DIAGC_au8EveSts[333]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008899 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[334] "DIAGC_au8EveSts[334]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000889A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[335] "DIAGC_au8EveSts[335]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000889B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[336] "DIAGC_au8EveSts[336]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000889C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[337] "DIAGC_au8EveSts[337]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000889D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[338] "DIAGC_au8EveSts[338]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000889E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[339] "DIAGC_au8EveSts[339]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000889F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[33] "DIAGC_au8EveSts[33]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000876D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[340] "DIAGC_au8EveSts[340]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600088A0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[341] "DIAGC_au8EveSts[341]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600088A1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[342] "DIAGC_au8EveSts[342]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600088A2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[343] "DIAGC_au8EveSts[343]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600088A3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[344] "DIAGC_au8EveSts[344]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600088A4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[345] "DIAGC_au8EveSts[345]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600088A5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[346] "DIAGC_au8EveSts[346]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600088A6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[347] "DIAGC_au8EveSts[347]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600088A7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[348] "DIAGC_au8EveSts[348]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600088A8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[349] "DIAGC_au8EveSts[349]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600088A9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[34] "DIAGC_au8EveSts[34]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000876E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[350] "DIAGC_au8EveSts[350]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600088AA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[351] "DIAGC_au8EveSts[351]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600088AB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[352] "DIAGC_au8EveSts[352]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600088AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[353] "DIAGC_au8EveSts[353]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600088AD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[354] "DIAGC_au8EveSts[354]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600088AE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[355] "DIAGC_au8EveSts[355]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600088AF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[356] "DIAGC_au8EveSts[356]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600088B0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[357] "DIAGC_au8EveSts[357]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600088B1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[358] "DIAGC_au8EveSts[358]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600088B2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[359] "DIAGC_au8EveSts[359]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600088B3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[35] "DIAGC_au8EveSts[35]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000876F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[360] "DIAGC_au8EveSts[360]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600088B4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[361] "DIAGC_au8EveSts[361]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600088B5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[362] "DIAGC_au8EveSts[362]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600088B6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[363] "DIAGC_au8EveSts[363]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600088B7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[36] "DIAGC_au8EveSts[36]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008770 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[37] "DIAGC_au8EveSts[37]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008771 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[38] "DIAGC_au8EveSts[38]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008772 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[39] "DIAGC_au8EveSts[39]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008773 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[3] "DIAGC_au8EveSts[3]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000874F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[40] "DIAGC_au8EveSts[40]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008774 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[41] "DIAGC_au8EveSts[41]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008775 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[42] "DIAGC_au8EveSts[42]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008776 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[43] "DIAGC_au8EveSts[43]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008777 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[44] "DIAGC_au8EveSts[44]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008778 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[45] "DIAGC_au8EveSts[45]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008779 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[46] "DIAGC_au8EveSts[46]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000877A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[47] "DIAGC_au8EveSts[47]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000877B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[48] "DIAGC_au8EveSts[48]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000877C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[49] "DIAGC_au8EveSts[49]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000877D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[4] "DIAGC_au8EveSts[4]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008750 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[50] "DIAGC_au8EveSts[50]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000877E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[51] "DIAGC_au8EveSts[51]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000877F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[52] "DIAGC_au8EveSts[52]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008780 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[53] "DIAGC_au8EveSts[53]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008781 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[54] "DIAGC_au8EveSts[54]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008782 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[55] "DIAGC_au8EveSts[55]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008783 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[56] "DIAGC_au8EveSts[56]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008784 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[57] "DIAGC_au8EveSts[57]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008785 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[58] "DIAGC_au8EveSts[58]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008786 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[59] "DIAGC_au8EveSts[59]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008787 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[5] "DIAGC_au8EveSts[5]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008751 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[60] "DIAGC_au8EveSts[60]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008788 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[61] "DIAGC_au8EveSts[61]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008789 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[62] "DIAGC_au8EveSts[62]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000878A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[63] "DIAGC_au8EveSts[63]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000878B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[64] "DIAGC_au8EveSts[64]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000878C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[65] "DIAGC_au8EveSts[65]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000878D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[66] "DIAGC_au8EveSts[66]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000878E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[67] "DIAGC_au8EveSts[67]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000878F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[68] "DIAGC_au8EveSts[68]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008790 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[69] "DIAGC_au8EveSts[69]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008791 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[6] "DIAGC_au8EveSts[6]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008752 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[70] "DIAGC_au8EveSts[70]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008792 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[71] "DIAGC_au8EveSts[71]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008793 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[72] "DIAGC_au8EveSts[72]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008794 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[73] "DIAGC_au8EveSts[73]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008795 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[74] "DIAGC_au8EveSts[74]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008796 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[75] "DIAGC_au8EveSts[75]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008797 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[76] "DIAGC_au8EveSts[76]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008798 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[77] "DIAGC_au8EveSts[77]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008799 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[78] "DIAGC_au8EveSts[78]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000879A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[79] "DIAGC_au8EveSts[79]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000879B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[7] "DIAGC_au8EveSts[7]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008753 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[80] "DIAGC_au8EveSts[80]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000879C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[81] "DIAGC_au8EveSts[81]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000879D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[82] "DIAGC_au8EveSts[82]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000879E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[83] "DIAGC_au8EveSts[83]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000879F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[84] "DIAGC_au8EveSts[84]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087A0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[85] "DIAGC_au8EveSts[85]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087A1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[86] "DIAGC_au8EveSts[86]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087A2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[87] "DIAGC_au8EveSts[87]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087A3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[88] "DIAGC_au8EveSts[88]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087A4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[89] "DIAGC_au8EveSts[89]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087A5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[8] "DIAGC_au8EveSts[8]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008754 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[90] "DIAGC_au8EveSts[90]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087A6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[91] "DIAGC_au8EveSts[91]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087A7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[92] "DIAGC_au8EveSts[92]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087A8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[93] "DIAGC_au8EveSts[93]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087A9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[94] "DIAGC_au8EveSts[94]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087AA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[95] "DIAGC_au8EveSts[95]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087AB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[96] "DIAGC_au8EveSts[96]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[97] "DIAGC_au8EveSts[97]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087AD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[98] "DIAGC_au8EveSts[98]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087AE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[99] "DIAGC_au8EveSts[99]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600087AF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8EveSts[9] "DIAGC_au8EveSts[9]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008755 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach "Lost commucation counter." UBYTE F_1_p0_7 1 2 0 0 MATRIX_DIM 1 67 1 ECU_ADDRESS 0x60008628 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[0] "DIAGC_au8GroupDiagTiReach[0]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008628 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[10] "DIAGC_au8GroupDiagTiReach[10]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008632 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[11] "DIAGC_au8GroupDiagTiReach[11]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008633 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[12] "DIAGC_au8GroupDiagTiReach[12]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008634 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[13] "DIAGC_au8GroupDiagTiReach[13]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008635 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[14] "DIAGC_au8GroupDiagTiReach[14]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008636 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[15] "DIAGC_au8GroupDiagTiReach[15]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008637 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[16] "DIAGC_au8GroupDiagTiReach[16]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008638 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[17] "DIAGC_au8GroupDiagTiReach[17]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008639 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[18] "DIAGC_au8GroupDiagTiReach[18]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000863A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[19] "DIAGC_au8GroupDiagTiReach[19]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000863B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[1] "DIAGC_au8GroupDiagTiReach[1]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008629 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[20] "DIAGC_au8GroupDiagTiReach[20]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000863C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[21] "DIAGC_au8GroupDiagTiReach[21]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000863D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[22] "DIAGC_au8GroupDiagTiReach[22]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000863E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[23] "DIAGC_au8GroupDiagTiReach[23]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000863F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[24] "DIAGC_au8GroupDiagTiReach[24]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008640 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[25] "DIAGC_au8GroupDiagTiReach[25]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008641 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[26] "DIAGC_au8GroupDiagTiReach[26]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008642 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[27] "DIAGC_au8GroupDiagTiReach[27]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008643 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[28] "DIAGC_au8GroupDiagTiReach[28]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008644 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[29] "DIAGC_au8GroupDiagTiReach[29]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008645 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[2] "DIAGC_au8GroupDiagTiReach[2]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000862A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[30] "DIAGC_au8GroupDiagTiReach[30]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008646 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[31] "DIAGC_au8GroupDiagTiReach[31]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008647 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[32] "DIAGC_au8GroupDiagTiReach[32]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008648 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[33] "DIAGC_au8GroupDiagTiReach[33]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008649 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[34] "DIAGC_au8GroupDiagTiReach[34]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000864A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[35] "DIAGC_au8GroupDiagTiReach[35]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000864B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[36] "DIAGC_au8GroupDiagTiReach[36]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000864C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[37] "DIAGC_au8GroupDiagTiReach[37]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000864D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[38] "DIAGC_au8GroupDiagTiReach[38]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000864E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[39] "DIAGC_au8GroupDiagTiReach[39]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000864F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[3] "DIAGC_au8GroupDiagTiReach[3]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000862B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[40] "DIAGC_au8GroupDiagTiReach[40]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008650 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[41] "DIAGC_au8GroupDiagTiReach[41]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008651 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[42] "DIAGC_au8GroupDiagTiReach[42]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008652 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[43] "DIAGC_au8GroupDiagTiReach[43]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008653 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[44] "DIAGC_au8GroupDiagTiReach[44]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008654 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[45] "DIAGC_au8GroupDiagTiReach[45]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008655 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[46] "DIAGC_au8GroupDiagTiReach[46]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008656 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[47] "DIAGC_au8GroupDiagTiReach[47]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008657 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[48] "DIAGC_au8GroupDiagTiReach[48]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008658 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[49] "DIAGC_au8GroupDiagTiReach[49]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008659 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[4] "DIAGC_au8GroupDiagTiReach[4]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000862C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[50] "DIAGC_au8GroupDiagTiReach[50]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000865A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[51] "DIAGC_au8GroupDiagTiReach[51]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000865B READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[52] "DIAGC_au8GroupDiagTiReach[52]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000865C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[53] "DIAGC_au8GroupDiagTiReach[53]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000865D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[54] "DIAGC_au8GroupDiagTiReach[54]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000865E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[55] "DIAGC_au8GroupDiagTiReach[55]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000865F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[56] "DIAGC_au8GroupDiagTiReach[56]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008660 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[57] "DIAGC_au8GroupDiagTiReach[57]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008661 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[58] "DIAGC_au8GroupDiagTiReach[58]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008662 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[59] "DIAGC_au8GroupDiagTiReach[59]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008663 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[5] "DIAGC_au8GroupDiagTiReach[5]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000862D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[60] "DIAGC_au8GroupDiagTiReach[60]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008664 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[61] "DIAGC_au8GroupDiagTiReach[61]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008665 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[62] "DIAGC_au8GroupDiagTiReach[62]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008666 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[63] "DIAGC_au8GroupDiagTiReach[63]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008667 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[64] "DIAGC_au8GroupDiagTiReach[64]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008668 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[65] "DIAGC_au8GroupDiagTiReach[65]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008669 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[66] "DIAGC_au8GroupDiagTiReach[66]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000866A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[6] "DIAGC_au8GroupDiagTiReach[6]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000862E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[7] "DIAGC_au8GroupDiagTiReach[7]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x6000862F READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[8] "DIAGC_au8GroupDiagTiReach[8]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008630 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_au8GroupDiagTiReach[9] "DIAGC_au8GroupDiagTiReach[9]" UBYTE F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x60008631 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT DIAGC_u32LostCommDiagCnt "Lost commucation counter." ULONG F_1_p0_7 1 2 0 0 ECU_ADDRESS 0x600009DC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT IOHAL_s16VarRead_ACCEL_X_AXIS "IOHAL_s16VarRead_ACCEL_X_AXIS" SWORD F_1_p0_16 1 2 -32768 32767 ECU_ADDRESS 0x600009F0 /end MEASUREMENT
/begin MEASUREMENT IOHAL_s16VarRead_ACCEL_Y_AXIS "IOHAL_s16VarRead_ACCEL_Y_AXIS" SWORD F_1_p0_16 1 2 -32768 32767 ECU_ADDRESS 0x600009F4 /end MEASUREMENT
/begin MEASUREMENT IOHAL_s16VarRead_ACCEL_Z_AXIS "IOHAL_s16VarRead_ACCEL_Z_AXIS" SWORD F_1_p0_16 1 2 -32768 32767 ECU_ADDRESS 0x600009F8 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u16VarRead_AN_DIAG_HS_SW_1_2 "IOHAL_u16VarRead_AN_DIAG_HS_SW_1_2" UWORD F_0v0012207031_p0_12 1 2 0 79.9987793 ECU_ADDRESS 0x60000AC8 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u16VarRead_AN_DIAG_HS_SW_3_4 "IOHAL_u16VarRead_AN_DIAG_HS_SW_3_4" UWORD F_0v0012207031_p0_12 1 2 0 79.9987793 ECU_ADDRESS 0x60000ACC /end MEASUREMENT
/begin MEASUREMENT IOHAL_u16VarRead_AN_DIAG_SOL_SW_1 "IOHAL_u16VarRead_AN_DIAG_SOL_SW_1" UWORD F_0v0012207031_p0_12 1 2 0 79.9987793 ECU_ADDRESS 0x60000A50 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u16VarRead_AN_DIAG_SOL_SW_2 "IOHAL_u16VarRead_AN_DIAG_SOL_SW_2" UWORD F_0v0012207031_p0_12 1 2 0 79.9987793 ECU_ADDRESS 0x60000A54 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u16VarRead_AN_DIAG_SOL_SW_3 "IOHAL_u16VarRead_AN_DIAG_SOL_SW_3" UWORD F_0v0012207031_p0_12 1 2 0 79.9987793 ECU_ADDRESS 0x60000A58 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u16VarRead_AN_DIAG_SOL_SW_4 "IOHAL_u16VarRead_AN_DIAG_SOL_SW_4" UWORD F_0v0012207031_p0_12 1 2 0 79.9987793 ECU_ADDRESS 0x60000A5C /end MEASUREMENT
/begin MEASUREMENT IOHAL_u16VarRead_AN_ENG_SPD_HALL "IOHAL_u16VarRead_AN_ENG_SPD_HALL" UWORD F_0v0012207031_p0_12 1 2 0 79.9987793 ECU_ADDRESS 0x60000AC4 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u16VarRead_AN_ENG_SPD_VR "IOHAL_u16VarRead_AN_ENG_SPD_VR" UWORD F_0v0012207031_p0_12 1 2 0 79.9987793 ECU_ADDRESS 0x60000A80 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u16VarRead_AN_INPUT_SPD_HALL "IOHAL_u16VarRead_AN_INPUT_SPD_HALL" UWORD F_0v0012207031_p0_12 1 2 0 79.9987793 ECU_ADDRESS 0x60000AB4 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u16VarRead_AN_INPUT_SPD_VR "IOHAL_u16VarRead_AN_INPUT_SPD_VR" UWORD F_0v0012207031_p0_12 1 2 0 79.9987793 ECU_ADDRESS 0x60000A74 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u16VarRead_AN_IN_ANLG_TEMP_1 "IOHAL_u16VarRead_AN_IN_ANLG_TEMP_1" UWORD F_0v0012207031_p0_12 1 2 0 79.9987793 ECU_ADDRESS 0x60000A94 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u16VarRead_AN_IN_ANLG_TEMP_2 "IOHAL_u16VarRead_AN_IN_ANLG_TEMP_2" UWORD F_0v0012207031_p0_12 1 2 0 79.9987793 ECU_ADDRESS 0x60000AAC /end MEASUREMENT
/begin MEASUREMENT IOHAL_u16VarRead_AN_IN_ANLG_TEMP_3 "IOHAL_u16VarRead_AN_IN_ANLG_TEMP_3" UWORD F_0v0012207031_p0_12 1 2 0 79.9987793 ECU_ADDRESS 0x60000A7C /end MEASUREMENT
/begin MEASUREMENT IOHAL_u16VarRead_AN_IN_ANLG_VOLT_1 "IOHAL_u16VarRead_AN_IN_ANLG_VOLT_1" UWORD F_0v0012207031_p0_12 1 2 0 79.9987793 ECU_ADDRESS 0x60000AB8 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u16VarRead_AN_IN_ANLG_VOLT_2 "IOHAL_u16VarRead_AN_IN_ANLG_VOLT_2" UWORD F_0v0012207031_p0_12 1 2 0 79.9987793 ECU_ADDRESS 0x60000A8C /end MEASUREMENT
/begin MEASUREMENT IOHAL_u16VarRead_AN_IN_ANLG_VOLT_3 "IOHAL_u16VarRead_AN_IN_ANLG_VOLT_3" UWORD F_0v0012207031_p0_12 1 2 0 79.9987793 ECU_ADDRESS 0x60000AC0 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u16VarRead_AN_IN_ANLG_VOLT_4 "IOHAL_u16VarRead_AN_IN_ANLG_VOLT_4" UWORD F_0v0012207031_p0_12 1 2 0 79.9987793 ECU_ADDRESS 0x60000ABC /end MEASUREMENT
/begin MEASUREMENT IOHAL_u16VarRead_AN_IN_ANLG_VOLT_5 "IOHAL_u16VarRead_AN_IN_ANLG_VOLT_5" UWORD F_0v0012207031_p0_12 1 2 0 79.9987793 ECU_ADDRESS 0x60000A90 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u16VarRead_AN_IN_ANLG_VOLT_6 "IOHAL_u16VarRead_AN_IN_ANLG_VOLT_6" UWORD F_0v0012207031_p0_12 1 2 0 79.9987793 ECU_ADDRESS 0x60000A64 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u16VarRead_AN_OUTPUT_SPD_HALL "IOHAL_u16VarRead_AN_OUTPUT_SPD_HALL" UWORD F_0v0012207031_p0_12 1 2 0 79.9987793 ECU_ADDRESS 0x60000AA4 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u16VarRead_AN_OUTPUT_SPD_VR "IOHAL_u16VarRead_AN_OUTPUT_SPD_VR" UWORD F_0v0012207031_p0_12 1 2 0 79.9987793 ECU_ADDRESS 0x60000A68 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u16VarRead_AN_P5V_SNS_SUP_1 "IOHAL_u16VarRead_AN_P5V_SNS_SUP_1" UWORD F_0v0012207031_p0_12 1 2 0 79.9987793 ECU_ADDRESS 0x60000A60 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u16VarRead_AN_P5V_SNS_SUP_2 "IOHAL_u16VarRead_AN_P5V_SNS_SUP_2" UWORD F_0v0012207031_p0_12 1 2 0 79.9987793 ECU_ADDRESS 0x60000A9C /end MEASUREMENT
/begin MEASUREMENT IOHAL_u16VarRead_AN_P9V_SENS_SUP_2_1 "IOHAL_u16VarRead_AN_P9V_SENS_SUP_2_1" UWORD F_0v0012207031_p0_12 1 2 0 79.9987793 ECU_ADDRESS 0x60000AB0 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u16VarRead_AN_P9V_SENS_SUP_2_2 "IOHAL_u16VarRead_AN_P9V_SENS_SUP_2_2" UWORD F_0v0012207031_p0_12 1 2 0 79.9987793 ECU_ADDRESS 0x60000AA8 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u16VarRead_AN_P9V_SNS_SUP_1 "IOHAL_u16VarRead_AN_P9V_SNS_SUP_1" UWORD F_0v0012207031_p0_12 1 2 0 79.9987793 ECU_ADDRESS 0x60000A6C /end MEASUREMENT
/begin MEASUREMENT IOHAL_u16VarRead_AN_PWM_IN_1 "IOHAL_u16VarRead_AN_PWM_IN_1" UWORD F_0v0012207031_p0_12 1 2 0 79.9987793 ECU_ADDRESS 0x60000A98 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u16VarRead_AN_PWM_IN_2 "IOHAL_u16VarRead_AN_PWM_IN_2" UWORD F_0v0012207031_p0_12 1 2 0 79.9987793 ECU_ADDRESS 0x60000A84 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u16VarRead_AN_PWM_IN_3 "IOHAL_u16VarRead_AN_PWM_IN_3" UWORD F_0v0012207031_p0_12 1 2 0 79.9987793 ECU_ADDRESS 0x60000A88 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u16VarRead_AN_TMP_PCB "IOHAL_u16VarRead_AN_TMP_PCB" UWORD F_0v0012207031_p0_12 1 2 0 79.9987793 ECU_ADDRESS 0x60000A70 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u16VarRead_AN_VBAT_KL30_SW_SUP "IOHAL_u16VarRead_AN_VBAT_KL30_SW_SUP" UWORD F_0v0012207031_p0_12 1 2 0 79.9987793 ECU_ADDRESS 0x60000A78 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u16VarRead_AN_VBAT_P_SW_SUP "IOHAL_u16VarRead_AN_VBAT_P_SW_SUP" UWORD F_0v0012207031_p0_12 1 2 0 79.9987793 ECU_ADDRESS 0x60000AD0 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u16VarRead_AN_VCC_5V_SUP "IOHAL_u16VarRead_AN_VCC_5V_SUP" UWORD F_0v0012207031_p0_12 1 2 0 79.9987793 ECU_ADDRESS 0x60000AA0 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u16VarRead_LSD_SPEEDOMETER_CMD "IOHAL_u16VarRead_LSD_SPEEDOMETER_CMD" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60000AE0 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u16VarWrite_LSD_SPEEDOMETER_CMD "IOHAL_u16VarWrite_LSD_SPEEDOMETER_CMD" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60000ADC /end MEASUREMENT
/begin MEASUREMENT IOHAL_u16VarWrite_PWM_DUTY_SPEEDOMETER "IOHAL_u16VarWrite_PWM_DUTY_SPEEDOMETER" UWORD F_1_p0_6 1 2 0 65535 ECU_ADDRESS 0x60000AD8 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u32VarRead_ENG_SPD_HALL_PWM_DUTYCYC "IOHAL_u32VarRead_ENG_SPD_HALL_PWM_DUTYCYC" ULONG F_1_p0_6 1 2 0 4294967295 ECU_ADDRESS 0x60000A1C /end MEASUREMENT
/begin MEASUREMENT IOHAL_u32VarRead_ENG_SPD_HALL_PWM_FRQ "IOHAL_u32VarRead_ENG_SPD_HALL_PWM_FRQ" ULONG F_1_p0_6 1 2 0 4294967295 ECU_ADDRESS 0x60000A40 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u32VarRead_ENG_SPD_HALL_PWM_TON "IOHAL_u32VarRead_ENG_SPD_HALL_PWM_TON" ULONG F_1_p0_6 1 2 0 4294967295 ECU_ADDRESS 0x60000A00 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u32VarRead_ENG_SPD_VR_PWM_DUTYCYC "IOHAL_u32VarRead_ENG_SPD_VR_PWM_DUTYCYC" ULONG F_1_p0_6 1 2 0 4294967295 ECU_ADDRESS 0x60000A10 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u32VarRead_ENG_SPD_VR_PWM_FRQ "IOHAL_u32VarRead_ENG_SPD_VR_PWM_FRQ" ULONG F_1_p0_6 1 2 0 4294967295 ECU_ADDRESS 0x60000A34 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u32VarRead_INPUT_SPD_HALL_PWM_DUTYCYC "IOHAL_u32VarRead_INPUT_SPD_HALL_PWM_DUTYCYC" ULONG F_1_p0_6 1 2 0 4294967295 ECU_ADDRESS 0x60000A18 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u32VarRead_INPUT_SPD_HALL_PWM_FRQ "IOHAL_u32VarRead_INPUT_SPD_HALL_PWM_FRQ" ULONG F_1_p0_6 1 2 0 4294967295 ECU_ADDRESS 0x60000A3C /end MEASUREMENT
/begin MEASUREMENT IOHAL_u32VarRead_INPUT_SPD_HALL_PWM_TON "IOHAL_u32VarRead_INPUT_SPD_HALL_PWM_TON" ULONG F_1_p0_6 1 2 0 4294967295 ECU_ADDRESS 0x600009FC /end MEASUREMENT
/begin MEASUREMENT IOHAL_u32VarRead_INPUT_SPD_VR_PWM_DUTYCYC "IOHAL_u32VarRead_INPUT_SPD_VR_PWM_DUTYCYC" ULONG F_1_p0_6 1 2 0 4294967295 ECU_ADDRESS 0x60000A0C /end MEASUREMENT
/begin MEASUREMENT IOHAL_u32VarRead_INPUT_SPD_VR_PWM_FRQ "IOHAL_u32VarRead_INPUT_SPD_VR_PWM_FRQ" ULONG F_1_p0_6 1 2 0 4294967295 ECU_ADDRESS 0x60000A30 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u32VarRead_OUTPUT_SPD_HALL_PWM_DUTYCYC "IOHAL_u32VarRead_OUTPUT_SPD_HALL_PWM_DUTYCYC" ULONG F_1_p0_6 1 2 0 4294967295 ECU_ADDRESS 0x60000A14 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u32VarRead_OUTPUT_SPD_HALL_PWM_FRQ "IOHAL_u32VarRead_OUTPUT_SPD_HALL_PWM_FRQ" ULONG F_1_p0_6 1 2 0 4294967295 ECU_ADDRESS 0x60000A38 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u32VarRead_OUTPUT_SPD_HALL_PWM_TON "IOHAL_u32VarRead_OUTPUT_SPD_HALL_PWM_TON" ULONG F_1_p0_6 1 2 0 4294967295 ECU_ADDRESS 0x60000A04 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u32VarRead_OUTPUT_SPD_VR_PWM_DUTYCYC "IOHAL_u32VarRead_OUTPUT_SPD_VR_PWM_DUTYCYC" ULONG F_1_p0_6 1 2 0 4294967295 ECU_ADDRESS 0x60000A08 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u32VarRead_OUTPUT_SPD_VR_PWM_FRQ "IOHAL_u32VarRead_OUTPUT_SPD_VR_PWM_FRQ" ULONG F_1_p0_6 1 2 0 4294967295 ECU_ADDRESS 0x60000A2C /end MEASUREMENT
/begin MEASUREMENT IOHAL_u32VarRead_PWM_IN_1_DUTYCYC "IOHAL_u32VarRead_PWM_IN_1_DUTYCYC" ULONG F_1_p0_6 1 2 0 4294967295 ECU_ADDRESS 0x60000A28 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u32VarRead_PWM_IN_1_FRQ "IOHAL_u32VarRead_PWM_IN_1_FRQ" ULONG F_1_p0_6 1 2 0 4294967295 ECU_ADDRESS 0x60000A4C /end MEASUREMENT
/begin MEASUREMENT IOHAL_u32VarRead_PWM_IN_2_DUTYCYC "IOHAL_u32VarRead_PWM_IN_2_DUTYCYC" ULONG F_1_p0_6 1 2 0 4294967295 ECU_ADDRESS 0x60000A24 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u32VarRead_PWM_IN_2_FRQ "IOHAL_u32VarRead_PWM_IN_2_FRQ" ULONG F_1_p0_6 1 2 0 4294967295 ECU_ADDRESS 0x60000A48 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u32VarRead_PWM_IN_3_DUTYCYC "IOHAL_u32VarRead_PWM_IN_3_DUTYCYC" ULONG F_1_p0_6 1 2 0 4294967295 ECU_ADDRESS 0x60000A20 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u32VarRead_PWM_IN_3_FRQ "IOHAL_u32VarRead_PWM_IN_3_FRQ" ULONG F_1_p0_6 1 2 0 4294967295 ECU_ADDRESS 0x60000A44 /end MEASUREMENT
/begin MEASUREMENT IOHAL_u32VarWrite_PWM_FRQ_SPEEDOMETER "IOHAL_u32VarWrite_PWM_FRQ_SPEEDOMETER" ULONG F_1_p0_6 1 2 0 4294967295 ECU_ADDRESS 0x60000AD4 /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag "lost communication flag" UBYTE I_5 1 2 0 255 MATRIX_DIM 73 1 1 ECU_ADDRESS 0x6000A1A0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[0] "J1939_u8lostComFlag[0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1A0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[10] "J1939_u8lostComFlag[10]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1AA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[11] "J1939_u8lostComFlag[11]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1AB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[12] "J1939_u8lostComFlag[12]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[13] "J1939_u8lostComFlag[13]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1AD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[14] "J1939_u8lostComFlag[14]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1AE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[15] "J1939_u8lostComFlag[15]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1AF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[16] "J1939_u8lostComFlag[16]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1B0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[17] "J1939_u8lostComFlag[17]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1B1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[18] "J1939_u8lostComFlag[18]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1B2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[19] "J1939_u8lostComFlag[19]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1B3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[1] "J1939_u8lostComFlag[1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1A1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[20] "J1939_u8lostComFlag[20]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1B4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[21] "J1939_u8lostComFlag[21]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1B5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[22] "J1939_u8lostComFlag[22]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1B6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[23] "J1939_u8lostComFlag[23]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1B7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[24] "J1939_u8lostComFlag[24]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1B8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[25] "J1939_u8lostComFlag[25]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1B9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[26] "J1939_u8lostComFlag[26]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1BA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[27] "J1939_u8lostComFlag[27]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1BB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[28] "J1939_u8lostComFlag[28]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1BC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[29] "J1939_u8lostComFlag[29]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1BD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[2] "J1939_u8lostComFlag[2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1A2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[30] "J1939_u8lostComFlag[30]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1BE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[31] "J1939_u8lostComFlag[31]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1BF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[32] "J1939_u8lostComFlag[32]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1C0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[33] "J1939_u8lostComFlag[33]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1C1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[34] "J1939_u8lostComFlag[34]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1C2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[35] "J1939_u8lostComFlag[35]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1C3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[36] "J1939_u8lostComFlag[36]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1C4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[37] "J1939_u8lostComFlag[37]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1C5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[38] "J1939_u8lostComFlag[38]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1C6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[39] "J1939_u8lostComFlag[39]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1C7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[3] "J1939_u8lostComFlag[3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1A3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[40] "J1939_u8lostComFlag[40]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1C8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[41] "J1939_u8lostComFlag[41]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1C9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[42] "J1939_u8lostComFlag[42]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1CA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[43] "J1939_u8lostComFlag[43]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1CB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[44] "J1939_u8lostComFlag[44]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1CC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[45] "J1939_u8lostComFlag[45]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1CD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[46] "J1939_u8lostComFlag[46]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1CE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[47] "J1939_u8lostComFlag[47]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1CF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[48] "J1939_u8lostComFlag[48]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1D0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[49] "J1939_u8lostComFlag[49]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1D1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[4] "J1939_u8lostComFlag[4]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1A4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[50] "J1939_u8lostComFlag[50]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1D2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[51] "J1939_u8lostComFlag[51]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1D3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[52] "J1939_u8lostComFlag[52]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1D4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[53] "J1939_u8lostComFlag[53]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1D5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[54] "J1939_u8lostComFlag[54]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1D6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[55] "J1939_u8lostComFlag[55]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1D7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[56] "J1939_u8lostComFlag[56]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1D8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[57] "J1939_u8lostComFlag[57]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1D9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[58] "J1939_u8lostComFlag[58]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1DA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[59] "J1939_u8lostComFlag[59]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1DB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[5] "J1939_u8lostComFlag[5]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1A5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[60] "J1939_u8lostComFlag[60]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1DC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[61] "J1939_u8lostComFlag[61]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1DD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[62] "J1939_u8lostComFlag[62]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1DE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[63] "J1939_u8lostComFlag[63]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1DF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[64] "J1939_u8lostComFlag[64]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1E0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[65] "J1939_u8lostComFlag[65]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1E1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[66] "J1939_u8lostComFlag[66]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1E2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[67] "J1939_u8lostComFlag[67]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1E3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[68] "J1939_u8lostComFlag[68]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1E4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[69] "J1939_u8lostComFlag[69]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1E5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[6] "J1939_u8lostComFlag[6]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1A6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[70] "J1939_u8lostComFlag[70]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1E6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[71] "J1939_u8lostComFlag[71]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1E7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[72] "J1939_u8lostComFlag[72]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1E8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[7] "J1939_u8lostComFlag[7]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1A7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[8] "J1939_u8lostComFlag[8]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1A8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT J1939_u8lostComFlag[9] "J1939_u8lostComFlag[9]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x6000A1A9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT KAM_u32FailAddr "KAM_u32FailAddr" ULONG F_1_p0_7 1 2 0 4294967295 ECU_ADDRESS 0x60000D40 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT KAM_u8InitSts "KAM_u8InitSts" UBYTE F_1_p0_7 1 2 0 255 ECU_ADDRESS 0x60000D44 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_f32Trim2Nvm "NvM test" FLOAT32_IEEE I_5 1 2 -2147483648 2147483647 ECU_ADDRESS 0x600008E8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_s16TestVar1 "MAIN_s16TestVar1" SWORD I_5 1 2 -32768 32767 ECU_ADDRESS 0x600008C6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_s16TestVar2 "MAIN_s16TestVar2" SWORD I_5 1 2 -32768 32767 ECU_ADDRESS 0x600008C4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_s16TestVar3 "MAIN_s16TestVar3" SWORD I_5 1 2 -32768 32767 ECU_ADDRESS 0x600008C2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_s16TestVar4 "MAIN_s16TestVar4" SWORD I_5 1 2 -32768 32767 ECU_ADDRESS 0x600008C0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_s32TestVar1 "MAIN_s32TestVar1" SLONG I_5 1 2 -2147483648 2147483647 ECU_ADDRESS 0x60000858 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_s32TestVar2 "MAIN_s32TestVar2" SLONG I_5 1 2 -2147483648 2147483647 ECU_ADDRESS 0x60000854 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_s32TestVar3 "MAIN_s32TestVar3" SLONG I_5 1 2 -2147483648 2147483647 ECU_ADDRESS 0x60000850 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_s32TestVar4 "MAIN_s32TestVar4" SLONG I_5 1 2 -2147483648 2147483647 ECU_ADDRESS 0x6000084C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_s32Trim3Nvm "NvM test" SLONG I_5 1 2 -2147483648 2147483647 ECU_ADDRESS 0x60000848 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_s8TestVar1 "MAIN_s8TestVar1" SBYTE I_5 1 2 -128 127 ECU_ADDRESS 0x600008D2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_s8TestVar2 "MAIN_s8TestVar2" SBYTE I_5 1 2 -128 127 ECU_ADDRESS 0x600008D1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_s8TestVar3 "MAIN_s8TestVar3" SBYTE I_5 1 2 -128 127 ECU_ADDRESS 0x600008D0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_s8TestVar4 "MAIN_s8TestVar4" SBYTE I_5 1 2 -128 127 ECU_ADDRESS 0x600008CF READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TestIpduCtrl "MAIN_u16TestIpduCtrl" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600008CE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TestIpduCtrlEna "MAIN_u16TestIpduCtrlEna" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600008CD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TestIpduCtrlIdx "MAIN_u16TestIpduCtrlIdx" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600008CC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TestVar1 "MAIN_u16TestVar1" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x600008BE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TestVar2 "MAIN_u16TestVar2" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x600008BC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TestVar3 "MAIN_u16TestVar3" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x600008BA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TestVar4 "MAIN_u16TestVar4" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x600008B8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr1000msCpu0 "MAIN_u16TskCtr1000msCpu0" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x600008B6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr1000msCpu1Lvl1 "MAIN_u16TskCtr1000msCpu1Lvl1" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x600008B4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr1000msCpu1Lvl2 "MAIN_u16TskCtr1000msCpu1Lvl2" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x600008B2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr1000msCpu1Lvl3 "MAIN_u16TskCtr1000msCpu1Lvl3" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x600008B0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr1000msCpu2 "MAIN_u16TskCtr1000msCpu2" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x600008AE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr100msCpu0 "MAIN_u16TskCtr100msCpu0" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x600008AC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr100msCpu1Lvl1 "MAIN_u16TskCtr100msCpu1Lvl1" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x600008AA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr100msCpu1Lvl2 "MAIN_u16TskCtr100msCpu1Lvl2" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x600008A8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr100msCpu1Lvl3 "MAIN_u16TskCtr100msCpu1Lvl3" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x600008A6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr100msCpu2 "MAIN_u16TskCtr100msCpu2" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x600008A4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr10msCpu0 "MAIN_u16TskCtr10msCpu0" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x600008A2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr10msCpu1Lvl1 "MAIN_u16TskCtr10msCpu1Lvl1" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x600008A0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr10msCpu1Lvl2 "MAIN_u16TskCtr10msCpu1Lvl2" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x6000089E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr10msCpu1Lvl3 "MAIN_u16TskCtr10msCpu1Lvl3" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x6000089C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr10msCpu2 "MAIN_u16TskCtr10msCpu2" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x6000089A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr1msCpu0 "MAIN_u16TskCtr1msCpu0" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60000898 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr1msCpu1Lvl1 "MAIN_u16TskCtr1msCpu1Lvl1" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60000896 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr1msCpu1Lvl2 "MAIN_u16TskCtr1msCpu1Lvl2" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60000894 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr1msCpu1Lvl3 "MAIN_u16TskCtr1msCpu1Lvl3" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60000892 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr1msCpu2 "MAIN_u16TskCtr1msCpu2" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60000890 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr200msCpu0 "MAIN_u16TskCtr200msCpu0" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x6000088E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr200msCpu1Lvl1 "MAIN_u16TskCtr200msCpu1Lvl1" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x6000088C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr200msCpu1Lvl2 "MAIN_u16TskCtr200msCpu1Lvl2" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x6000088A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr200msCpu1Lvl3 "MAIN_u16TskCtr200msCpu1Lvl3" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60000888 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr200msCpu2 "MAIN_u16TskCtr200msCpu2" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60000886 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr20msCpu0 "MAIN_u16TskCtr20msCpu0" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60000884 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr20msCpu1Lvl1 "MAIN_u16TskCtr20msCpu1Lvl1" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60000882 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr20msCpu1Lvl2 "MAIN_u16TskCtr20msCpu1Lvl2" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60000880 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr20msCpu1Lvl3 "MAIN_u16TskCtr20msCpu1Lvl3" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x6000087E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr20msCpu2 "MAIN_u16TskCtr20msCpu2" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x6000087C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr2msCpu0 "MAIN_u16TskCtr2msCpu0" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x6000087A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr2msCpu1Lvl1 "MAIN_u16TskCtr2msCpu1Lvl1" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60000878 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr2msCpu1Lvl2 "MAIN_u16TskCtr2msCpu1Lvl2" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60000876 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr2msCpu1Lvl3 "MAIN_u16TskCtr2msCpu1Lvl3" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60000874 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr2msCpu2 "MAIN_u16TskCtr2msCpu2" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60000872 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr5000msCpu0 "MAIN_u16TskCtr5000msCpu0" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60000870 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr50msCpu0 "MAIN_u16TskCtr50msCpu0" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x6000086E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr50msCpu1Lvl1 "MAIN_u16TskCtr50msCpu1Lvl1" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x6000086C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr50msCpu1Lvl2 "MAIN_u16TskCtr50msCpu1Lvl2" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x6000086A READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr50msCpu1Lvl3 "MAIN_u16TskCtr50msCpu1Lvl3" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60000868 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr50msCpu2 "MAIN_u16TskCtr50msCpu2" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60000866 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr5msCpu0 "MAIN_u16TskCtr5msCpu0" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60000864 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr5msCpu1Lvl1 "MAIN_u16TskCtr5msCpu1Lvl1" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60000862 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr5msCpu1Lvl2 "MAIN_u16TskCtr5msCpu1Lvl2" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60000860 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr5msCpu1Lvl3 "MAIN_u16TskCtr5msCpu1Lvl3" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x6000085E READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u16TskCtr5msCpu2 "MAIN_u16TskCtr5msCpu2" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x6000085C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u32TestVar1 "MAIN_u32TestVar1" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600008E4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u32TestVar2 "MAIN_u32TestVar2" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600008E0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u32TestVar3 "MAIN_u32TestVar3" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600008DC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u32TestVar4 "MAIN_u32TestVar4" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600008D8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u32Trim1Nvm "NvM test" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x600008D4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u8FaultNvm "NvM test" UBYTE I_5 1 2 0 255 MATRIX_DIM 10 1 1 ECU_ADDRESS 0x60006DC0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u8FaultNvm[0] "MAIN_u8FaultNvm[0]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60006DC0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u8FaultNvm[1] "MAIN_u8FaultNvm[1]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60006DC1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u8FaultNvm[2] "MAIN_u8FaultNvm[2]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60006DC2 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u8FaultNvm[3] "MAIN_u8FaultNvm[3]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60006DC3 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u8FaultNvm[4] "MAIN_u8FaultNvm[4]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60006DC4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u8FaultNvm[5] "MAIN_u8FaultNvm[5]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60006DC5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u8FaultNvm[6] "MAIN_u8FaultNvm[6]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60006DC6 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u8FaultNvm[7] "MAIN_u8FaultNvm[7]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60006DC7 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u8FaultNvm[8] "MAIN_u8FaultNvm[8]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60006DC8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u8FaultNvm[9] "MAIN_u8FaultNvm[9]" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x60006DC9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u8TestVar1 "MAIN_u8TestVar1" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600008CB READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u8TestVar2 "MAIN_u8TestVar2" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600008CA READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u8TestVar3 "MAIN_u8TestVar3" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600008C9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT MAIN_u8TestVar4 "MAIN_u8TestVar4" UBYTE I_5 1 2 0 255 ECU_ADDRESS 0x600008C8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_bCurrentLvlIsActive_ENG_SPD_HALL_PWM "PWD_bCurrentLvlIsActive_ENG_SPD_HALL_PWM" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60000C60 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_bCurrentLvlIsActive_ENG_SPD_VR_PWM "PWD_bCurrentLvlIsActive_ENG_SPD_VR_PWM" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60000BDC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_bCurrentLvlIsActive_INPUT_SPD_HALL_PWM "PWD_bCurrentLvlIsActive_INPUT_SPD_HALL_PWM" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60000C34 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_bCurrentLvlIsActive_INPUT_SPD_VR_PWM "PWD_bCurrentLvlIsActive_INPUT_SPD_VR_PWM" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60000BB0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_bCurrentLvlIsActive_OUTPUT_SPD_HALL_PWM "PWD_bCurrentLvlIsActive_OUTPUT_SPD_HALL_PWM" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60000C08 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_bCurrentLvlIsActive_OUTPUT_SPD_VR_PWM "PWD_bCurrentLvlIsActive_OUTPUT_SPD_VR_PWM" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60000B84 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_bCurrentLvlIsActive_PWM_IN_1 "PWD_bCurrentLvlIsActive_PWM_IN_1" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60000CE4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_bCurrentLvlIsActive_PWM_IN_2 "PWD_bCurrentLvlIsActive_PWM_IN_2" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60000CB8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_bCurrentLvlIsActive_PWM_IN_3 "PWD_bCurrentLvlIsActive_PWM_IN_3" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60000C8C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_bEna_ENG_SPD_HALL_PWM "PWD_bEna_ENG_SPD_HALL_PWM" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60000C78 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_bEna_ENG_SPD_VR_PWM "PWD_bEna_ENG_SPD_VR_PWM" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60000BF4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_bEna_INPUT_SPD_HALL_PWM "PWD_bEna_INPUT_SPD_HALL_PWM" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60000C4C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_bEna_INPUT_SPD_VR_PWM "PWD_bEna_INPUT_SPD_VR_PWM" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60000BC8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_bEna_OUTPUT_SPD_HALL_PWM "PWD_bEna_OUTPUT_SPD_HALL_PWM" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60000C20 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_bEna_OUTPUT_SPD_VR_PWM "PWD_bEna_OUTPUT_SPD_VR_PWM" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60000B9C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_bEna_PWM_IN_1 "PWD_bEna_PWM_IN_1" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60000CFC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_bEna_PWM_IN_2 "PWD_bEna_PWM_IN_2" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60000CD0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_bEna_PWM_IN_3 "PWD_bEna_PWM_IN_3" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60000CA4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_bEnableAll "PWD_bEnableAll" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60000D00 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_bFirstPerOccured_ENG_SPD_HALL_PWM "PWD_bFirstPerOccured_ENG_SPD_HALL_PWM" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60000C61 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_bFirstPerOccured_ENG_SPD_VR_PWM "PWD_bFirstPerOccured_ENG_SPD_VR_PWM" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60000BDD READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_bFirstPerOccured_INPUT_SPD_HALL_PWM "PWD_bFirstPerOccured_INPUT_SPD_HALL_PWM" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60000C35 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_bFirstPerOccured_INPUT_SPD_VR_PWM "PWD_bFirstPerOccured_INPUT_SPD_VR_PWM" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60000BB1 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_bFirstPerOccured_OUTPUT_SPD_HALL_PWM "PWD_bFirstPerOccured_OUTPUT_SPD_HALL_PWM" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60000C09 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_bFirstPerOccured_OUTPUT_SPD_VR_PWM "PWD_bFirstPerOccured_OUTPUT_SPD_VR_PWM" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60000B85 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_bFirstPerOccured_PWM_IN_1 "PWD_bFirstPerOccured_PWM_IN_1" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60000CE5 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_bFirstPerOccured_PWM_IN_2 "PWD_bFirstPerOccured_PWM_IN_2" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60000CB9 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_bFirstPerOccured_PWM_IN_3 "PWD_bFirstPerOccured_PWM_IN_3" UBYTE Bool_ON_OFF 1 2 0 1 BIT_MASK 0x01 ECU_ADDRESS 0x60000C8D READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_u16UpdateDisable "PWD_u16UpdateDisable" UWORD I_5 1 2 0 65535 ECU_ADDRESS 0x60000CFE READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_udtDuty_ENG_SPD_HALL_PWM "PWD_udtDuty_ENG_SPD_HALL_PWM" UWORD F_0v0030517578_p0_19 1 2 0 199.9969482 ECU_ADDRESS 0x60000C68 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_udtDuty_ENG_SPD_VR_PWM "PWD_udtDuty_ENG_SPD_VR_PWM" UWORD F_0v0030517578_p0_19 1 2 0 199.9969482 ECU_ADDRESS 0x60000BE4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_udtDuty_INPUT_SPD_HALL_PWM "PWD_udtDuty_INPUT_SPD_HALL_PWM" UWORD F_0v0030517578_p0_19 1 2 0 199.9969482 ECU_ADDRESS 0x60000C3C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_udtDuty_INPUT_SPD_VR_PWM "PWD_udtDuty_INPUT_SPD_VR_PWM" UWORD F_0v0030517578_p0_19 1 2 0 199.9969482 ECU_ADDRESS 0x60000BB8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_udtDuty_OUTPUT_SPD_HALL_PWM "PWD_udtDuty_OUTPUT_SPD_HALL_PWM" UWORD F_0v0030517578_p0_19 1 2 0 199.9969482 ECU_ADDRESS 0x60000C10 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_udtDuty_OUTPUT_SPD_VR_PWM "PWD_udtDuty_OUTPUT_SPD_VR_PWM" UWORD F_0v0030517578_p0_19 1 2 0 199.9969482 ECU_ADDRESS 0x60000B8C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_udtDuty_PWM_IN_1 "PWD_udtDuty_PWM_IN_1" UWORD F_0v0030517578_p0_19 1 2 0 199.9969482 ECU_ADDRESS 0x60000CEC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_udtDuty_PWM_IN_2 "PWD_udtDuty_PWM_IN_2" UWORD F_0v0030517578_p0_19 1 2 0 199.9969482 ECU_ADDRESS 0x60000CC0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_udtDuty_PWM_IN_3 "PWD_udtDuty_PWM_IN_3" UWORD F_0v0030517578_p0_19 1 2 0 199.9969482 ECU_ADDRESS 0x60000C94 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_udtPer_ENG_SPD_HALL_PWM "PWD_udtPer_ENG_SPD_HALL_PWM" ULONG F_0v0001_p0_20 1 2 0 429496.7295 ECU_ADDRESS 0x60000C74 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_udtPer_ENG_SPD_VR_PWM "PWD_udtPer_ENG_SPD_VR_PWM" ULONG F_0v0001_p0_20 1 2 0 429496.7295 ECU_ADDRESS 0x60000BF0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_udtPer_INPUT_SPD_HALL_PWM "PWD_udtPer_INPUT_SPD_HALL_PWM" ULONG F_0v0001_p0_20 1 2 0 429496.7295 ECU_ADDRESS 0x60000C48 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_udtPer_INPUT_SPD_VR_PWM "PWD_udtPer_INPUT_SPD_VR_PWM" ULONG F_0v0001_p0_20 1 2 0 429496.7295 ECU_ADDRESS 0x60000BC4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_udtPer_OUTPUT_SPD_HALL_PWM "PWD_udtPer_OUTPUT_SPD_HALL_PWM" ULONG F_0v0001_p0_20 1 2 0 429496.7295 ECU_ADDRESS 0x60000C1C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_udtPer_OUTPUT_SPD_VR_PWM "PWD_udtPer_OUTPUT_SPD_VR_PWM" ULONG F_0v0001_p0_20 1 2 0 429496.7295 ECU_ADDRESS 0x60000B98 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_udtPer_PWM_IN_1 "PWD_udtPer_PWM_IN_1" ULONG F_0v0001_p0_20 1 2 0 429496.7295 ECU_ADDRESS 0x60000CF8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_udtPer_PWM_IN_2 "PWD_udtPer_PWM_IN_2" ULONG F_0v0001_p0_20 1 2 0 429496.7295 ECU_ADDRESS 0x60000CCC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_udtPer_PWM_IN_3 "PWD_udtPer_PWM_IN_3" ULONG F_0v0001_p0_20 1 2 0 429496.7295 ECU_ADDRESS 0x60000CA0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_udtToutRloadVal_ENG_SPD_HALL_PWM "Value of timeout of DF PLUG PWM channel" ULONG F_1000_p0_18 1 2 0 4.294967295E+012 ECU_ADDRESS 0x60000C64 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_udtToutRloadVal_ENG_SPD_VR_PWM "Value of timeout of DF PLUG PWM channel" ULONG F_1000_p0_18 1 2 0 4.294967295E+012 ECU_ADDRESS 0x60000BE0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_udtToutRloadVal_INPUT_SPD_HALL_PWM "Value of timeout of DF PLUG PWM channel" ULONG F_1000_p0_18 1 2 0 4.294967295E+012 ECU_ADDRESS 0x60000C38 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_udtToutRloadVal_INPUT_SPD_VR_PWM "Value of timeout of DF PLUG PWM channel" ULONG F_1000_p0_18 1 2 0 4.294967295E+012 ECU_ADDRESS 0x60000BB4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_udtToutRloadVal_OUTPUT_SPD_HALL_PWM "Value of timeout of DF PLUG PWM channel" ULONG F_1000_p0_18 1 2 0 4.294967295E+012 ECU_ADDRESS 0x60000C0C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_udtToutRloadVal_OUTPUT_SPD_VR_PWM "Value of timeout of DF PLUG PWM channel" ULONG F_1000_p0_18 1 2 0 4.294967295E+012 ECU_ADDRESS 0x60000B88 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_udtToutRloadVal_PWM_IN_1 "Value of timeout of DF PLUG PWM channel" ULONG F_1000_p0_18 1 2 0 4.294967295E+012 ECU_ADDRESS 0x60000CE8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_udtToutRloadVal_PWM_IN_2 "Value of timeout of DF PLUG PWM channel" ULONG F_1000_p0_18 1 2 0 4.294967295E+012 ECU_ADDRESS 0x60000CBC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_udtToutRloadVal_PWM_IN_3 "Value of timeout of DF PLUG PWM channel" ULONG F_1000_p0_18 1 2 0 4.294967295E+012 ECU_ADDRESS 0x60000C90 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_udtTout_ENG_SPD_HALL_PWM "Value of timeout of DF PLUG PWM channel" ULONG F_1000_p0_18 1 2 0 4.294967295E+012 ECU_ADDRESS 0x60000C5C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_udtTout_ENG_SPD_VR_PWM "Value of timeout of DF PLUG PWM channel" ULONG F_1000_p0_18 1 2 0 4.294967295E+012 ECU_ADDRESS 0x60000BD8 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_udtTout_INPUT_SPD_HALL_PWM "Value of timeout of DF PLUG PWM channel" ULONG F_4000_p0_21 1 2 0 1.717986918E+013 ECU_ADDRESS 0x60000C30 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_udtTout_INPUT_SPD_VR_PWM "Value of timeout of DF PLUG PWM channel" ULONG F_1000_p0_18 1 2 0 4.294967295E+012 ECU_ADDRESS 0x60000BAC READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_udtTout_OUTPUT_SPD_HALL_PWM "Value of timeout of DF PLUG PWM channel" ULONG F_1000_p0_18 1 2 0 4.294967295E+012 ECU_ADDRESS 0x60000C04 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_udtTout_OUTPUT_SPD_VR_PWM "Value of timeout of DF PLUG PWM channel" ULONG F_1000_p0_18 1 2 0 4.294967295E+012 ECU_ADDRESS 0x60000B80 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_udtTout_PWM_IN_1 "Value of timeout of DF PLUG PWM channel" ULONG F_1000_p0_18 1 2 0 4.294967295E+012 ECU_ADDRESS 0x60000CE0 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_udtTout_PWM_IN_2 "Value of timeout of DF PLUG PWM channel" ULONG F_1000_p0_18 1 2 0 4.294967295E+012 ECU_ADDRESS 0x60000CB4 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT PWD_udtTout_PWM_IN_3 "Value of timeout of DF PLUG PWM channel" ULONG F_1000_p0_18 1 2 0 4.294967295E+012 ECU_ADDRESS 0x60000C88 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_Lvl2RamCrc_u32GlbLvl2TstVar "TST_Lvl2RamCrc_u32GlbLvl2TstVar" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60000808 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_Lvl2RamCrc_u32InitGlbLvl1TstVar "TST_Lvl2RamCrc_u32InitGlbLvl1TstVar" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60006D30 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_Lvl2RamCrc_u32InitGlbLvl2TstVar "TST_Lvl2RamCrc_u32InitGlbLvl2TstVar" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60000814 READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_Lvl2RamCrc_u32PwrOnClrGlbLvl2TstVar "TST_Lvl2RamCrc_u32PwrOnClrGlbLvl2TstVar" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x6000080C READ_WRITE /end MEASUREMENT
/begin MEASUREMENT TST_Lvl2RamCrc_u32PwrOnInitGlbLvl2TstVar "TST_Lvl2RamCrc_u32PwrOnInitGlbLvl2TstVar" ULONG I_5 1 2 0 4294967295 ECU_ADDRESS 0x60000810 READ_WRITE /end MEASUREMENT
/begin COMPU_METHOD I_5 "" RAT_FUNC "%9.2" "-" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD F_1_p0_6 "" RAT_FUNC "%9.2" "-" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD F_1_p0_7 "" RAT_FUNC "%9.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD F_0v0012207031_p0_12 "" RAT_FUNC "%9.3" "V" COEFFS 0 1 0 0 0 0.0012207 /end COMPU_METHOD
/begin COMPU_METHOD F_0v013431013_p0_13 "" RAT_FUNC "%9.2" "V" COEFFS 0 1 0 0 0 0.013431 /end COMPU_METHOD
/begin COMPU_METHOD F_0v002442002_p0_14 "" RAT_FUNC "%9.3" "V" COEFFS 0 1 0 0 0 0.002442 /end COMPU_METHOD
/begin COMPU_METHOD F_0v004389422_p0_15 "" RAT_FUNC "%9.3" "V" COEFFS 0 1 0 0 0 0.00438942 /end COMPU_METHOD
/begin COMPU_METHOD F_1_p0_16 "" RAT_FUNC "%9.2" "g" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD F_1000_p0_18 "" RAT_FUNC "%9.2" "ms" COEFFS 0 1 0 0 0 1000 /end COMPU_METHOD
/begin COMPU_METHOD F_0v0030517578_p0_19 "" RAT_FUNC "%9.3" "%" COEFFS 0 1 0 0 0 0.00305176 /end COMPU_METHOD
/begin COMPU_METHOD F_0v0001_p0_20 "" RAT_FUNC "%9.4" "ms" COEFFS 0 1 0 0 0 0.0001 /end COMPU_METHOD
/begin COMPU_METHOD F_4000_p0_21 "" RAT_FUNC "%9.2" "ms" COEFFS 0 1 0 0 0 4000 /end COMPU_METHOD
/begin COMPU_METHOD Id_0x00 "" RAT_FUNC "%9.2" "." COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Bool_ON_OFF "" TAB_VERB "%8.4" "." COMPU_TAB_REF Bool_ON_OFF_table /end COMPU_METHOD
/begin COMPU_VTAB Bool_ON_OFF_table "" TAB_VERB 2 0 "OFF" 1 "ON" /end COMPU_VTAB
/begin FUNCTION DemJ1939Wrapper "" FUNCTION_VERSION "NONE_"
 /begin DEF_CHARACTERISTIC BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve11Underload BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve12GeneralFault BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve12Open BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve12Overload BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve12ShortToBatt BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve12ShortToGndOpenCircuit BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve12Underload BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve13GeneralFault BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve13Open BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve13Overload BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve13ShortToBatt BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve13ShortToGndOpenCircuit BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve13Underload BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve44GeneralFault BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve44Open BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve44Overload BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve44ShortToBatt BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve44ShortToGndOpenCircuit BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve44Underload BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve45GeneralFault BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve45Open BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve45Overload BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve45ShortToBatt BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve45ShortToGnd BSW_ku8J1939LampCodeForSolenoidLsdProportionalX5PwmValve45Underload BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd1OpenCircuit BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd1Overload BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd1ShortToBattOpenCircuit BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd1ShortToGnd BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd1Underload BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd2OpenCircuit BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd2Overload BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd2ShortToBattOpenCircuit BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd2ShortToGnd BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd2Underload BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd3OpenCircuit BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd3Overload BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd3ShortToBattOpenCircuit BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd3ShortToGnd BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd3Underload BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd4OpenCircuit BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd4Overload BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd4ShortToBattOpenCircuit BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd4ShortToGnd BSW_ku8J1939LampCodeForSolenoidsHsdIsolatorX4CommonHsd4Underload BSW_ku8J1939LampCodeForSpeedSensorsVrEngSpdVrNShortToBatt BSW_ku8J1939LampCodeForSpeedSensorsVrEngSpdVrNShortToGndOpenCircuit BSW_ku8J1939LampCodeForSpeedSensorsVrInputSpdVrNShortToBatt BSW_ku8J1939LampCodeForSpeedSensorsVrInputSpdVrNShortToGndOpenCircuit BSW_ku8J1939LampCodeForSpeedSensorsVrOutputSpdVrNShortToBatt BSW_ku8J1939LampCodeForSpeedSensorsVrOutputSpdVrNShortToGndOpenCircuit BSW_ku8J1939LampCodeForSuppliesP5vSensor21OutOfHighRange BSW_ku8J1939LampCodeForSuppliesP5vSensor21OutOfLowRange BSW_ku8J1939LampCodeForSuppliesP5vSensor21ShortToBatt BSW_ku8J1939LampCodeForSuppliesP5vSensor21ShortToGnd BSW_ku8J1939LampCodeForSuppliesP5vSensor22OutOfHighRange BSW_ku8J1939LampCodeForSuppliesP5vSensor22OutOfLowRange BSW_ku8J1939LampCodeForSuppliesP5vSensor22ShortToBatt BSW_ku8J1939LampCodeForSuppliesP5vSensor22ShortToGnd BSW_ku8J1939LampCodeForSuppliesP9vSnsSup1OutOfHighRange BSW_ku8J1939LampCodeForSuppliesP9vSnsSup1OutOfLowRange BSW_ku8J1939LampCodeForSuppliesP9vSnsSup1ShortToBatt BSW_ku8J1939LampCodeForSuppliesP9vSnsSup1ShortToGnd BSW_ku8J1939LampCodeForSuppliesP9vSnsSup21OutOfHighRange BSW_ku8J1939LampCodeForSuppliesP9vSnsSup21OutOfLowRange BSW_ku8J1939LampCodeForSuppliesP9vSnsSup21ShortToBatt BSW_ku8J1939LampCodeForSuppliesP9vSnsSup21ShortToGnd BSW_ku8J1939LampCodeForSuppliesP9vSnsSup22OutOfHighRange BSW_ku8J1939LampCodeForSuppliesP9vSnsSup22OutOfLowRange BSW_ku8J1939LampCodeForSuppliesP9vSnsSup22ShortToBatt BSW_ku8J1939LampCodeForSuppliesP9vSnsSup22ShortToGnd /end DEF_CHARACTERISTIC
/end FUNCTION
/begin FUNCTION Diagnostic "" FUNCTION_VERSION "NONE_"
 /begin DEF_CHARACTERISTIC DIAGC_aku16AnInpScsThd DIAGC_aku16AnInpScThd DIAGC_aku16PwmInpScsThd DIAGC_aku16PwmInpScThd DIAGC_aku16SpdSnsrScsThd DIAGC_aku16SpdSnsrScThd DIAGC_aku16SplyHiRngThd DIAGC_aku16SplyLoRngThd DIAGC_aku16SplyScsThd DIAGC_aku16SplyScThd DIAGC_aku16VbatHiRngThd DIAGC_aku16VbatLoRngThd DIAGC_kbJ1939_Ccvs1_RX_SA_00_LostCommDemEvePerd DIAGC_kbJ1939_CCVS1_RX_SA_17_LostCommDemEvePerd DIAGC_kbJ1939_CCVS1_RX_SA_23_LostCommDemEvePerd DIAGC_kbJ1939_CCVS1_RX_SA_33_LostCommDemEvePerd DIAGC_kbJ1939_CCVS1_RX_SA_39_LostCommDemEvePerd DIAGC_kbJ1939_CCVS1_RX_SA_49_LostCommDemEvePerd DIAGC_kbJ1939_EBC1_RX_SA_00_LostCommDemEvePerd DIAGC_kbJ1939_EBC1_RX_SA_11_LostCommDemEvePerd DIAGC_kbJ1939_EBC1_RX_SA_23_LostCommDemEvePerd DIAGC_kbJ1939_EBC1_RX_SA_33_LostCommDemEvePerd DIAGC_kbJ1939_EBC1_RX_SA_49_LostCommDemEvePerd DIAGC_kbJ1939_EC1_RX_SA_00_LostCommDemEvePerd DIAGC_kbJ1939_EEC1_RX_SA_00_LostCommDemEvePerd DIAGC_kbJ1939_EEC2_RX_SA_00_LostCommDemEvePerd DIAGC_kbJ1939_EEC2_RX_SA_17_LostCommDemEvePerd DIAGC_kbJ1939_EEC2_RX_SA_33_LostCommDemEvePerd DIAGC_kbJ1939_EEC2_RX_SA_49_LostCommDemEvePerd DIAGC_kbJ1939_EEC3_RX_SA_00_LostCommDemEvePerd DIAGC_kbJ1939_ERC1_RX_SA_00_LostCommDemEvePerd DIAGC_kbJ1939_ERC1_RX_SA_15_LostCommDemEvePerd DIAGC_kbJ1939_ERC1_RX_SA_23_LostCommDemEvePerd DIAGC_kbJ1939_ERC1_RX_SA_33_LostCommDemEvePerd DIAGC_kbJ1939_ERC1_RX_SA_41_LostCommDemEvePerd DIAGC_kbJ1939_ERC1_RX_SA_49_LostCommDemEvePerd DIAGC_kbJ1939_ET1_RX_SA_00_LostCommDemEvePerd DIAGC_kbJ1939_LFE1_RX_SA_00_LostCommDemEvePerd DIAGC_kbJ1939_PTODE_RX_SA_23_LostCommDemEvePerd DIAGC_kbJ1939_PTODE_RX_SA_33_LostCommDemEvePerd DIAGC_kbJ1939_PTODE_RX_SA_49_LostCommDemEvePerd DIAGC_kbJ1939_RC_RX_SA_15_LostCommDemEvePerd DIAGC_kbJ1939_RC_RX_SA_41_LostCommDemEvePerd DIAGC_kbJ1939_RxMsg10Can1_LostCommDemEvePerd DIAGC_kbJ1939_RxMsg10Can2_LostCommDemEvePerd DIAGC_kbJ1939_RxMsg11Can1_LostCommDemEvePerd DIAGC_kbJ1939_RxMsg11Can2_LostCommDemEvePerd DIAGC_kbJ1939_RxMsg12Can1_LostCommDemEvePerd DIAGC_kbJ1939_RxMsg12Can2_LostCommDemEvePerd DIAGC_kbJ1939_RxMsg13Can1_LostCommDemEvePerd DIAGC_kbJ1939_RxMsg13Can2_LostCommDemEvePerd DIAGC_kbJ1939_RxMsg14Can1_LostCommDemEvePerd DIAGC_kbJ1939_RxMsg14Can2_LostCommDemEvePerd DIAGC_kbJ1939_RxMsg15Can1_LostCommDemEvePerd DIAGC_kbJ1939_RxMsg15Can2_LostCommDemEvePerd DIAGC_kbJ1939_RxMsg1Can1_LostCommDemEvePerd DIAGC_kbJ1939_RxMsg1Can2_LostCommDemEvePerd DIAGC_kbJ1939_RxMsg2Can1_LostCommDemEvePerd DIAGC_kbJ1939_RxMsg2Can2_LostCommDemEvePerd DIAGC_kbJ1939_RxMsg3Can1_LostCommDemEvePerd DIAGC_kbJ1939_RxMsg3Can2_LostCommDemEvePerd DIAGC_kbJ1939_RxMsg4Can1_LostCommDemEvePerd DIAGC_kbJ1939_RxMsg4Can2_LostCommDemEvePerd DIAGC_kbJ1939_RxMsg5Can1_LostCommDemEvePerd DIAGC_kbJ1939_RxMsg5Can2_LostCommDemEvePerd DIAGC_kbJ1939_RxMsg6Can1_LostCommDemEvePerd DIAGC_kbJ1939_RxMsg6Can2_LostCommDemEvePerd DIAGC_kbJ1939_RxMsg7Can1_LostCommDemEvePerd DIAGC_kbJ1939_RxMsg7Can2_LostCommDemEvePerd DIAGC_kbJ1939_RxMsg8Can1_LostCommDemEvePerd DIAGC_kbJ1939_RxMsg8Can2_LostCommDemEvePerd DIAGC_kbJ1939_RxMsg9Can1_LostCommDemEvePerd DIAGC_kbJ1939_RxMsg9Can2_LostCommDemEvePerd DIAGC_kbJ1939_TC1_RX_SA_05_LostCommDemEvePerd DIAGC_kbJ1939_TC1_RX_SA_06_LostCommDemEvePerd DIAGC_kbJ1939_TC1_RX_SA_23_LostCommDemEvePerd DIAGC_kbJ1939_TC1_RX_SA_33_LostCommDemEvePerd DIAGC_kbJ1939_TC1_RX_SA_42_LostCommDemEvePerd DIAGC_kbJ1939_TC1_RX_SA_49_LostCommDemEvePerd DIAGC_kbJ1939_TSC1_RX_SA_00_LostCommDemEvePerd DIAGC_kbJ1939_TSC1_RX_SA_11_LostCommDemEvePerd DIAGC_kbJ1939_TSC1_RX_SA_17_LostCommDemEvePerd DIAGC_kbJ1939_TSC1_RX_SA_33_LostCommDemEvePerd DIAGC_kbJ1939_TSC1_RX_SA_39_LostCommDemEvePerd DIAGC_kbJ1939_TSC1_RX_SA_42_LostCommDemEvePerd DIAGC_ku16PwmInpMaxDuty DIAGC_ku16PwmInpMinDuty DIAGC_ku16SplyHiRngThdP5V1 DIAGC_ku16SplyHiRngThdP5V2 DIAGC_ku16SplyHiRngThdP9V1 DIAGC_ku16SplyHiRngThdP9V2 DIAGC_ku16SplyHiRngThdP9V3 DIAGC_ku16SplyLoRngThdP5V1 DIAGC_ku16SplyLoRngThdP5V2 DIAGC_ku16SplyLoRngThdP9V1 DIAGC_ku16SplyLoRngThdP9V2 DIAGC_ku16SplyLoRngThdP9V3 DIAGC_ku16SplyMaxDuty DIAGC_ku16SplyMinDuty DIAGC_ku16SplyScsThdP5V1 DIAGC_ku16SplyScsThdP5V2 DIAGC_ku16SplyScsThdP9V1 DIAGC_ku16SplyScsThdP9V2 DIAGC_ku16SplyScsThdP9V3 DIAGC_ku16SplyScThdP5V1 DIAGC_ku16SplyScThdP5V2 DIAGC_ku16SplyScThdP9V1 DIAGC_ku16SplyScThdP9V2 DIAGC_ku16SplyScThdP9V3 DIAGC_ku16VbatExtremeHiThd DIAGC_ku16VbatPyThd DIAGC_ku8LostCommDiagDecStep DIAGC_ku8LostCommDiagIncStep DIAGC_ku8LostCommDiagMaxVal DIAGC_ku8LostCommDiagThd /end DEF_CHARACTERISTIC
 /begin OUT_MEASUREMENT BSW_ku32SwVers BSW_u8RstCnt DIAGC_au8ComJ1939MsgRxdCnt DIAGC_au8ComJ1939MsgRxdCnt[0] DIAGC_au8ComJ1939MsgRxdCnt[10] DIAGC_au8ComJ1939MsgRxdCnt[11] DIAGC_au8ComJ1939MsgRxdCnt[12] DIAGC_au8ComJ1939MsgRxdCnt[13] DIAGC_au8ComJ1939MsgRxdCnt[14] DIAGC_au8ComJ1939MsgRxdCnt[15] DIAGC_au8ComJ1939MsgRxdCnt[16] DIAGC_au8ComJ1939MsgRxdCnt[17] DIAGC_au8ComJ1939MsgRxdCnt[18] DIAGC_au8ComJ1939MsgRxdCnt[19] DIAGC_au8ComJ1939MsgRxdCnt[1] DIAGC_au8ComJ1939MsgRxdCnt[20] DIAGC_au8ComJ1939MsgRxdCnt[21] DIAGC_au8ComJ1939MsgRxdCnt[22] DIAGC_au8ComJ1939MsgRxdCnt[23] DIAGC_au8ComJ1939MsgRxdCnt[24] DIAGC_au8ComJ1939MsgRxdCnt[25] DIAGC_au8ComJ1939MsgRxdCnt[26] DIAGC_au8ComJ1939MsgRxdCnt[27] DIAGC_au8ComJ1939MsgRxdCnt[28] DIAGC_au8ComJ1939MsgRxdCnt[29] DIAGC_au8ComJ1939MsgRxdCnt[2] DIAGC_au8ComJ1939MsgRxdCnt[30] DIAGC_au8ComJ1939MsgRxdCnt[31] DIAGC_au8ComJ1939MsgRxdCnt[32] DIAGC_au8ComJ1939MsgRxdCnt[33] DIAGC_au8ComJ1939MsgRxdCnt[34] DIAGC_au8ComJ1939MsgRxdCnt[35] DIAGC_au8ComJ1939MsgRxdCnt[36] DIAGC_au8ComJ1939MsgRxdCnt[37] DIAGC_au8ComJ1939MsgRxdCnt[38] DIAGC_au8ComJ1939MsgRxdCnt[39] DIAGC_au8ComJ1939MsgRxdCnt[3] DIAGC_au8ComJ1939MsgRxdCnt[40] DIAGC_au8ComJ1939MsgRxdCnt[41] DIAGC_au8ComJ1939MsgRxdCnt[42] DIAGC_au8ComJ1939MsgRxdCnt[43] DIAGC_au8ComJ1939MsgRxdCnt[44] DIAGC_au8ComJ1939MsgRxdCnt[45] DIAGC_au8ComJ1939MsgRxdCnt[46] DIAGC_au8ComJ1939MsgRxdCnt[47] DIAGC_au8ComJ1939MsgRxdCnt[48] DIAGC_au8ComJ1939MsgRxdCnt[49] DIAGC_au8ComJ1939MsgRxdCnt[4] DIAGC_au8ComJ1939MsgRxdCnt[50] DIAGC_au8ComJ1939MsgRxdCnt[51] DIAGC_au8ComJ1939MsgRxdCnt[52] DIAGC_au8ComJ1939MsgRxdCnt[53] DIAGC_au8ComJ1939MsgRxdCnt[54] DIAGC_au8ComJ1939MsgRxdCnt[55] DIAGC_au8ComJ1939MsgRxdCnt[56] DIAGC_au8ComJ1939MsgRxdCnt[57] DIAGC_au8ComJ1939MsgRxdCnt[58] DIAGC_au8ComJ1939MsgRxdCnt[59] DIAGC_au8ComJ1939MsgRxdCnt[5] DIAGC_au8ComJ1939MsgRxdCnt[60] DIAGC_au8ComJ1939MsgRxdCnt[61] DIAGC_au8ComJ1939MsgRxdCnt[62] DIAGC_au8ComJ1939MsgRxdCnt[63] DIAGC_au8ComJ1939MsgRxdCnt[64] DIAGC_au8ComJ1939MsgRxdCnt[65] DIAGC_au8ComJ1939MsgRxdCnt[66] DIAGC_au8ComJ1939MsgRxdCnt[6] DIAGC_au8ComJ1939MsgRxdCnt[7] DIAGC_au8ComJ1939MsgRxdCnt[8] DIAGC_au8ComJ1939MsgRxdCnt[9] DIAGC_au8EveSts DIAGC_au8EveSts[0] DIAGC_au8EveSts[100] DIAGC_au8EveSts[101] DIAGC_au8EveSts[102] DIAGC_au8EveSts[103] DIAGC_au8EveSts[104] DIAGC_au8EveSts[105] DIAGC_au8EveSts[106] DIAGC_au8EveSts[107] DIAGC_au8EveSts[108] DIAGC_au8EveSts[109] DIAGC_au8EveSts[10] DIAGC_au8EveSts[110] DIAGC_au8EveSts[111] DIAGC_au8EveSts[112] DIAGC_au8EveSts[113] DIAGC_au8EveSts[114] DIAGC_au8EveSts[115] DIAGC_au8EveSts[116] DIAGC_au8EveSts[117] DIAGC_au8EveSts[118] DIAGC_au8EveSts[119] DIAGC_au8EveSts[11] DIAGC_au8EveSts[120] DIAGC_au8EveSts[121] DIAGC_au8EveSts[122] DIAGC_au8EveSts[123] DIAGC_au8EveSts[124] DIAGC_au8EveSts[125] DIAGC_au8EveSts[126] DIAGC_au8EveSts[127] DIAGC_au8EveSts[128] DIAGC_au8EveSts[129] DIAGC_au8EveSts[12] DIAGC_au8EveSts[130] DIAGC_au8EveSts[131] DIAGC_au8EveSts[132] DIAGC_au8EveSts[133] DIAGC_au8EveSts[134] DIAGC_au8EveSts[135] DIAGC_au8EveSts[136] DIAGC_au8EveSts[137] DIAGC_au8EveSts[138] DIAGC_au8EveSts[139] DIAGC_au8EveSts[13] DIAGC_au8EveSts[140] DIAGC_au8EveSts[141] DIAGC_au8EveSts[142] DIAGC_au8EveSts[143] DIAGC_au8EveSts[144] DIAGC_au8EveSts[145] DIAGC_au8EveSts[146] DIAGC_au8EveSts[147] DIAGC_au8EveSts[148] DIAGC_au8EveSts[149] DIAGC_au8EveSts[14] DIAGC_au8EveSts[150] DIAGC_au8EveSts[151] DIAGC_au8EveSts[152] DIAGC_au8EveSts[153] DIAGC_au8EveSts[154] DIAGC_au8EveSts[155] DIAGC_au8EveSts[156] DIAGC_au8EveSts[157] DIAGC_au8EveSts[158] DIAGC_au8EveSts[159] DIAGC_au8EveSts[15] DIAGC_au8EveSts[160] DIAGC_au8EveSts[161] DIAGC_au8EveSts[162] DIAGC_au8EveSts[163] DIAGC_au8EveSts[164] DIAGC_au8EveSts[165] DIAGC_au8EveSts[166] DIAGC_au8EveSts[167] DIAGC_au8EveSts[168] DIAGC_au8EveSts[169] DIAGC_au8EveSts[16] DIAGC_au8EveSts[170] DIAGC_au8EveSts[171] DIAGC_au8EveSts[172] DIAGC_au8EveSts[173] DIAGC_au8EveSts[174] DIAGC_au8EveSts[175] DIAGC_au8EveSts[176] DIAGC_au8EveSts[177] DIAGC_au8EveSts[178] DIAGC_au8EveSts[179] DIAGC_au8EveSts[17] DIAGC_au8EveSts[180] DIAGC_au8EveSts[181] DIAGC_au8EveSts[182] DIAGC_au8EveSts[183] DIAGC_au8EveSts[184] DIAGC_au8EveSts[185] DIAGC_au8EveSts[186] DIAGC_au8EveSts[187] DIAGC_au8EveSts[188] DIAGC_au8EveSts[189] DIAGC_au8EveSts[18] DIAGC_au8EveSts[190] DIAGC_au8EveSts[191] DIAGC_au8EveSts[192] DIAGC_au8EveSts[193] DIAGC_au8EveSts[194] DIAGC_au8EveSts[195] DIAGC_au8EveSts[196] DIAGC_au8EveSts[197] DIAGC_au8EveSts[198] DIAGC_au8EveSts[199] DIAGC_au8EveSts[19] DIAGC_au8EveSts[1] DIAGC_au8EveSts[200] DIAGC_au8EveSts[201] DIAGC_au8EveSts[202] DIAGC_au8EveSts[203] DIAGC_au8EveSts[204] DIAGC_au8EveSts[205] DIAGC_au8EveSts[206] DIAGC_au8EveSts[207] DIAGC_au8EveSts[208] DIAGC_au8EveSts[209] DIAGC_au8EveSts[20] DIAGC_au8EveSts[210] DIAGC_au8EveSts[211] DIAGC_au8EveSts[212] DIAGC_au8EveSts[213] DIAGC_au8EveSts[214] DIAGC_au8EveSts[215] DIAGC_au8EveSts[216] DIAGC_au8EveSts[217] DIAGC_au8EveSts[218] DIAGC_au8EveSts[219] DIAGC_au8EveSts[21] DIAGC_au8EveSts[220] DIAGC_au8EveSts[221] DIAGC_au8EveSts[222] DIAGC_au8EveSts[223] DIAGC_au8EveSts[224] DIAGC_au8EveSts[225] DIAGC_au8EveSts[226] DIAGC_au8EveSts[227] DIAGC_au8EveSts[228] DIAGC_au8EveSts[229] DIAGC_au8EveSts[22] DIAGC_au8EveSts[230] DIAGC_au8EveSts[231] DIAGC_au8EveSts[232] DIAGC_au8EveSts[233] DIAGC_au8EveSts[234] DIAGC_au8EveSts[235] DIAGC_au8EveSts[236] DIAGC_au8EveSts[237] DIAGC_au8EveSts[238] DIAGC_au8EveSts[239] DIAGC_au8EveSts[23] DIAGC_au8EveSts[240] DIAGC_au8EveSts[241] DIAGC_au8EveSts[242] DIAGC_au8EveSts[243] DIAGC_au8EveSts[244] DIAGC_au8EveSts[245] DIAGC_au8EveSts[246] DIAGC_au8EveSts[247] DIAGC_au8EveSts[248] DIAGC_au8EveSts[249] DIAGC_au8EveSts[24] DIAGC_au8EveSts[250] DIAGC_au8EveSts[251] DIAGC_au8EveSts[252] DIAGC_au8EveSts[253] DIAGC_au8EveSts[254] DIAGC_au8EveSts[255] DIAGC_au8EveSts[256] DIAGC_au8EveSts[257] DIAGC_au8EveSts[258] DIAGC_au8EveSts[259] DIAGC_au8EveSts[25] DIAGC_au8EveSts[260] DIAGC_au8EveSts[261] DIAGC_au8EveSts[262] DIAGC_au8EveSts[263] DIAGC_au8EveSts[264] DIAGC_au8EveSts[265] DIAGC_au8EveSts[266] DIAGC_au8EveSts[267] DIAGC_au8EveSts[268] DIAGC_au8EveSts[269] DIAGC_au8EveSts[26] DIAGC_au8EveSts[270] DIAGC_au8EveSts[271] DIAGC_au8EveSts[272] DIAGC_au8EveSts[273] DIAGC_au8EveSts[274] DIAGC_au8EveSts[275] DIAGC_au8EveSts[276] DIAGC_au8EveSts[277] DIAGC_au8EveSts[278] DIAGC_au8EveSts[279] DIAGC_au8EveSts[27] DIAGC_au8EveSts[280] DIAGC_au8EveSts[281] DIAGC_au8EveSts[282] DIAGC_au8EveSts[283] DIAGC_au8EveSts[284] DIAGC_au8EveSts[285] DIAGC_au8EveSts[286] DIAGC_au8EveSts[287] DIAGC_au8EveSts[288] DIAGC_au8EveSts[289] DIAGC_au8EveSts[28] DIAGC_au8EveSts[290] DIAGC_au8EveSts[291] DIAGC_au8EveSts[292] DIAGC_au8EveSts[293] DIAGC_au8EveSts[294] DIAGC_au8EveSts[295] DIAGC_au8EveSts[296] DIAGC_au8EveSts[297] DIAGC_au8EveSts[298] DIAGC_au8EveSts[299] DIAGC_au8EveSts[29] DIAGC_au8EveSts[2] DIAGC_au8EveSts[300] DIAGC_au8EveSts[301] DIAGC_au8EveSts[302] DIAGC_au8EveSts[303] DIAGC_au8EveSts[304] DIAGC_au8EveSts[305] DIAGC_au8EveSts[306] DIAGC_au8EveSts[307] DIAGC_au8EveSts[308] DIAGC_au8EveSts[309] DIAGC_au8EveSts[30] DIAGC_au8EveSts[310] DIAGC_au8EveSts[311] DIAGC_au8EveSts[312] DIAGC_au8EveSts[313] DIAGC_au8EveSts[314] DIAGC_au8EveSts[315] DIAGC_au8EveSts[316] DIAGC_au8EveSts[317] DIAGC_au8EveSts[318] DIAGC_au8EveSts[319] DIAGC_au8EveSts[31] DIAGC_au8EveSts[320] DIAGC_au8EveSts[321] DIAGC_au8EveSts[322] DIAGC_au8EveSts[323] DIAGC_au8EveSts[324] DIAGC_au8EveSts[325] DIAGC_au8EveSts[326] DIAGC_au8EveSts[327] DIAGC_au8EveSts[328] DIAGC_au8EveSts[329] DIAGC_au8EveSts[32] DIAGC_au8EveSts[330] DIAGC_au8EveSts[331] DIAGC_au8EveSts[332] DIAGC_au8EveSts[333] DIAGC_au8EveSts[334] DIAGC_au8EveSts[335] DIAGC_au8EveSts[336] DIAGC_au8EveSts[337] DIAGC_au8EveSts[338] DIAGC_au8EveSts[339] DIAGC_au8EveSts[33] DIAGC_au8EveSts[340] DIAGC_au8EveSts[341] DIAGC_au8EveSts[342] DIAGC_au8EveSts[343] DIAGC_au8EveSts[344] DIAGC_au8EveSts[345] DIAGC_au8EveSts[346] DIAGC_au8EveSts[347] DIAGC_au8EveSts[348] DIAGC_au8EveSts[349] DIAGC_au8EveSts[34] DIAGC_au8EveSts[350] DIAGC_au8EveSts[351] DIAGC_au8EveSts[352] DIAGC_au8EveSts[353] DIAGC_au8EveSts[354] DIAGC_au8EveSts[355] DIAGC_au8EveSts[356] DIAGC_au8EveSts[357] DIAGC_au8EveSts[358] DIAGC_au8EveSts[359] DIAGC_au8EveSts[35] DIAGC_au8EveSts[360] DIAGC_au8EveSts[361] DIAGC_au8EveSts[362] DIAGC_au8EveSts[363] DIAGC_au8EveSts[36] DIAGC_au8EveSts[37] DIAGC_au8EveSts[38] DIAGC_au8EveSts[39] DIAGC_au8EveSts[3] DIAGC_au8EveSts[40] DIAGC_au8EveSts[41] DIAGC_au8EveSts[42] DIAGC_au8EveSts[43] DIAGC_au8EveSts[44] DIAGC_au8EveSts[45] DIAGC_au8EveSts[46] DIAGC_au8EveSts[47] DIAGC_au8EveSts[48] DIAGC_au8EveSts[49] DIAGC_au8EveSts[4] DIAGC_au8EveSts[50] DIAGC_au8EveSts[51] DIAGC_au8EveSts[52] DIAGC_au8EveSts[53] DIAGC_au8EveSts[54] DIAGC_au8EveSts[55] DIAGC_au8EveSts[56] DIAGC_au8EveSts[57] DIAGC_au8EveSts[58] DIAGC_au8EveSts[59] DIAGC_au8EveSts[5] DIAGC_au8EveSts[60] DIAGC_au8EveSts[61] DIAGC_au8EveSts[62] DIAGC_au8EveSts[63] DIAGC_au8EveSts[64] DIAGC_au8EveSts[65] DIAGC_au8EveSts[66] DIAGC_au8EveSts[67] DIAGC_au8EveSts[68] DIAGC_au8EveSts[69] DIAGC_au8EveSts[6] DIAGC_au8EveSts[70] DIAGC_au8EveSts[71] DIAGC_au8EveSts[72] DIAGC_au8EveSts[73] DIAGC_au8EveSts[74] DIAGC_au8EveSts[75] DIAGC_au8EveSts[76] DIAGC_au8EveSts[77] DIAGC_au8EveSts[78] DIAGC_au8EveSts[79] DIAGC_au8EveSts[7] DIAGC_au8EveSts[80] DIAGC_au8EveSts[81] DIAGC_au8EveSts[82] DIAGC_au8EveSts[83] DIAGC_au8EveSts[84] DIAGC_au8EveSts[85] DIAGC_au8EveSts[86] DIAGC_au8EveSts[87] DIAGC_au8EveSts[88] DIAGC_au8EveSts[89] DIAGC_au8EveSts[8] DIAGC_au8EveSts[90] DIAGC_au8EveSts[91] DIAGC_au8EveSts[92] DIAGC_au8EveSts[93] DIAGC_au8EveSts[94] DIAGC_au8EveSts[95] DIAGC_au8EveSts[96] DIAGC_au8EveSts[97] DIAGC_au8EveSts[98] DIAGC_au8EveSts[99] DIAGC_au8EveSts[9] DIAGC_au8GroupDiagTiReach DIAGC_au8GroupDiagTiReach[0] DIAGC_au8GroupDiagTiReach[10] DIAGC_au8GroupDiagTiReach[11] DIAGC_au8GroupDiagTiReach[12] DIAGC_au8GroupDiagTiReach[13] DIAGC_au8GroupDiagTiReach[14] DIAGC_au8GroupDiagTiReach[15] DIAGC_au8GroupDiagTiReach[16] DIAGC_au8GroupDiagTiReach[17] DIAGC_au8GroupDiagTiReach[18] DIAGC_au8GroupDiagTiReach[19] DIAGC_au8GroupDiagTiReach[1] DIAGC_au8GroupDiagTiReach[20] DIAGC_au8GroupDiagTiReach[21] DIAGC_au8GroupDiagTiReach[22] DIAGC_au8GroupDiagTiReach[23] DIAGC_au8GroupDiagTiReach[24] DIAGC_au8GroupDiagTiReach[25] DIAGC_au8GroupDiagTiReach[26] DIAGC_au8GroupDiagTiReach[27] DIAGC_au8GroupDiagTiReach[28] DIAGC_au8GroupDiagTiReach[29] DIAGC_au8GroupDiagTiReach[2] DIAGC_au8GroupDiagTiReach[30] DIAGC_au8GroupDiagTiReach[31] DIAGC_au8GroupDiagTiReach[32] DIAGC_au8GroupDiagTiReach[33] DIAGC_au8GroupDiagTiReach[34] DIAGC_au8GroupDiagTiReach[35] DIAGC_au8GroupDiagTiReach[36] DIAGC_au8GroupDiagTiReach[37] DIAGC_au8GroupDiagTiReach[38] DIAGC_au8GroupDiagTiReach[39] DIAGC_au8GroupDiagTiReach[3] DIAGC_au8GroupDiagTiReach[40] DIAGC_au8GroupDiagTiReach[41] DIAGC_au8GroupDiagTiReach[42] DIAGC_au8GroupDiagTiReach[43] DIAGC_au8GroupDiagTiReach[44] DIAGC_au8GroupDiagTiReach[45] DIAGC_au8GroupDiagTiReach[46] DIAGC_au8GroupDiagTiReach[47] DIAGC_au8GroupDiagTiReach[48] DIAGC_au8GroupDiagTiReach[49] DIAGC_au8GroupDiagTiReach[4] DIAGC_au8GroupDiagTiReach[50] DIAGC_au8GroupDiagTiReach[51] DIAGC_au8GroupDiagTiReach[52] DIAGC_au8GroupDiagTiReach[53] DIAGC_au8GroupDiagTiReach[54] DIAGC_au8GroupDiagTiReach[55] DIAGC_au8GroupDiagTiReach[56] DIAGC_au8GroupDiagTiReach[57] DIAGC_au8GroupDiagTiReach[58] DIAGC_au8GroupDiagTiReach[59] DIAGC_au8GroupDiagTiReach[5] DIAGC_au8GroupDiagTiReach[60] DIAGC_au8GroupDiagTiReach[61] DIAGC_au8GroupDiagTiReach[62] DIAGC_au8GroupDiagTiReach[63] DIAGC_au8GroupDiagTiReach[64] DIAGC_au8GroupDiagTiReach[65] DIAGC_au8GroupDiagTiReach[66] DIAGC_au8GroupDiagTiReach[6] DIAGC_au8GroupDiagTiReach[7] DIAGC_au8GroupDiagTiReach[8] DIAGC_au8GroupDiagTiReach[9] DIAGC_u32LostCommDiagCnt /end OUT_MEASUREMENT
/end FUNCTION
/begin FUNCTION IOHAL ""
 /begin OUT_MEASUREMENT IOHAL_s16VarRead_ACCEL_X_AXIS IOHAL_s16VarRead_ACCEL_Y_AXIS IOHAL_s16VarRead_ACCEL_Z_AXIS IOHAL_u16VarRead_AN_DIAG_HS_SW_1_2 IOHAL_u16VarRead_AN_DIAG_HS_SW_3_4 IOHAL_u16VarRead_AN_DIAG_SOL_SW_1 IOHAL_u16VarRead_AN_DIAG_SOL_SW_2 IOHAL_u16VarRead_AN_DIAG_SOL_SW_3 IOHAL_u16VarRead_AN_DIAG_SOL_SW_4 IOHAL_u16VarRead_AN_ENG_SPD_HALL IOHAL_u16VarRead_AN_ENG_SPD_VR IOHAL_u16VarRead_AN_IN_ANLG_TEMP_1 IOHAL_u16VarRead_AN_IN_ANLG_TEMP_2 IOHAL_u16VarRead_AN_IN_ANLG_TEMP_3 IOHAL_u16VarRead_AN_IN_ANLG_VOLT_1 IOHAL_u16VarRead_AN_IN_ANLG_VOLT_2 IOHAL_u16VarRead_AN_IN_ANLG_VOLT_3 IOHAL_u16VarRead_AN_IN_ANLG_VOLT_4 IOHAL_u16VarRead_AN_IN_ANLG_VOLT_5 IOHAL_u16VarRead_AN_IN_ANLG_VOLT_6 IOHAL_u16VarRead_AN_INPUT_SPD_HALL IOHAL_u16VarRead_AN_INPUT_SPD_VR IOHAL_u16VarRead_AN_OUTPUT_SPD_HALL IOHAL_u16VarRead_AN_OUTPUT_SPD_VR IOHAL_u16VarRead_AN_P5V_SNS_SUP_1 IOHAL_u16VarRead_AN_P5V_SNS_SUP_2 IOHAL_u16VarRead_AN_P9V_SENS_SUP_2_1 IOHAL_u16VarRead_AN_P9V_SENS_SUP_2_2 IOHAL_u16VarRead_AN_P9V_SNS_SUP_1 IOHAL_u16VarRead_AN_PWM_IN_1 IOHAL_u16VarRead_AN_PWM_IN_2 IOHAL_u16VarRead_AN_PWM_IN_3 IOHAL_u16VarRead_AN_TMP_PCB IOHAL_u16VarRead_AN_VBAT_KL30_SW_SUP IOHAL_u16VarRead_AN_VBAT_P_SW_SUP IOHAL_u16VarRead_AN_VCC_5V_SUP IOHAL_u16VarRead_LSD_SPEEDOMETER_CMD IOHAL_u16VarWrite_LSD_SPEEDOMETER_CMD IOHAL_u16VarWrite_PWM_DUTY_SPEEDOMETER IOHAL_u32VarRead_ENG_SPD_HALL_PWM_DUTYCYC IOHAL_u32VarRead_ENG_SPD_HALL_PWM_FRQ IOHAL_u32VarRead_ENG_SPD_HALL_PWM_TON IOHAL_u32VarRead_ENG_SPD_VR_PWM_DUTYCYC IOHAL_u32VarRead_ENG_SPD_VR_PWM_FRQ IOHAL_u32VarRead_INPUT_SPD_HALL_PWM_DUTYCYC IOHAL_u32VarRead_INPUT_SPD_HALL_PWM_FRQ IOHAL_u32VarRead_INPUT_SPD_HALL_PWM_TON IOHAL_u32VarRead_INPUT_SPD_VR_PWM_DUTYCYC IOHAL_u32VarRead_INPUT_SPD_VR_PWM_FRQ IOHAL_u32VarRead_OUTPUT_SPD_HALL_PWM_DUTYCYC IOHAL_u32VarRead_OUTPUT_SPD_HALL_PWM_FRQ IOHAL_u32VarRead_OUTPUT_SPD_HALL_PWM_TON IOHAL_u32VarRead_OUTPUT_SPD_VR_PWM_DUTYCYC IOHAL_u32VarRead_OUTPUT_SPD_VR_PWM_FRQ IOHAL_u32VarRead_PWM_IN_1_DUTYCYC IOHAL_u32VarRead_PWM_IN_1_FRQ IOHAL_u32VarRead_PWM_IN_2_DUTYCYC IOHAL_u32VarRead_PWM_IN_2_FRQ IOHAL_u32VarRead_PWM_IN_3_DUTYCYC IOHAL_u32VarRead_PWM_IN_3_FRQ IOHAL_u32VarWrite_PWM_FRQ_SPEEDOMETER /end OUT_MEASUREMENT
/end FUNCTION
/begin FUNCTION J1939IF "" FUNCTION_VERSION "NONE_" /begin DEF_CHARACTERISTIC J1939_ku32Tsc1Sa03MsgId /end DEF_CHARACTERISTIC
 /begin OUT_MEASUREMENT J1939_u8lostComFlag J1939_u8lostComFlag[0] J1939_u8lostComFlag[10] J1939_u8lostComFlag[11] J1939_u8lostComFlag[12] J1939_u8lostComFlag[13] J1939_u8lostComFlag[14] J1939_u8lostComFlag[15] J1939_u8lostComFlag[16] J1939_u8lostComFlag[17] J1939_u8lostComFlag[18] J1939_u8lostComFlag[19] J1939_u8lostComFlag[1] J1939_u8lostComFlag[20] J1939_u8lostComFlag[21] J1939_u8lostComFlag[22] J1939_u8lostComFlag[23] J1939_u8lostComFlag[24] J1939_u8lostComFlag[25] J1939_u8lostComFlag[26] J1939_u8lostComFlag[27] J1939_u8lostComFlag[28] J1939_u8lostComFlag[29] J1939_u8lostComFlag[2] J1939_u8lostComFlag[30] J1939_u8lostComFlag[31] J1939_u8lostComFlag[32] J1939_u8lostComFlag[33] J1939_u8lostComFlag[34] J1939_u8lostComFlag[35] J1939_u8lostComFlag[36] J1939_u8lostComFlag[37] J1939_u8lostComFlag[38] J1939_u8lostComFlag[39] J1939_u8lostComFlag[3] J1939_u8lostComFlag[40] J1939_u8lostComFlag[41] J1939_u8lostComFlag[42] J1939_u8lostComFlag[43] J1939_u8lostComFlag[44] J1939_u8lostComFlag[45] J1939_u8lostComFlag[46] J1939_u8lostComFlag[47] J1939_u8lostComFlag[48] J1939_u8lostComFlag[49] J1939_u8lostComFlag[4] J1939_u8lostComFlag[50] J1939_u8lostComFlag[51] J1939_u8lostComFlag[52] J1939_u8lostComFlag[53] J1939_u8lostComFlag[54] J1939_u8lostComFlag[55] J1939_u8lostComFlag[56] J1939_u8lostComFlag[57] J1939_u8lostComFlag[58] J1939_u8lostComFlag[59] J1939_u8lostComFlag[5] J1939_u8lostComFlag[60] J1939_u8lostComFlag[61] J1939_u8lostComFlag[62] J1939_u8lostComFlag[63] J1939_u8lostComFlag[64] J1939_u8lostComFlag[65] J1939_u8lostComFlag[66] J1939_u8lostComFlag[67] J1939_u8lostComFlag[68] J1939_u8lostComFlag[69] J1939_u8lostComFlag[6] J1939_u8lostComFlag[70] J1939_u8lostComFlag[71] J1939_u8lostComFlag[72] J1939_u8lostComFlag[7] J1939_u8lostComFlag[8] J1939_u8lostComFlag[9] /end OUT_MEASUREMENT
/end FUNCTION
/begin FUNCTION KAM "" /begin OUT_MEASUREMENT KAM_u32FailAddr KAM_u8InitSts /end OUT_MEASUREMENT /end FUNCTION
/begin FUNCTION Lvl2RamCrc ""
 /begin OUT_MEASUREMENT TST_Lvl2RamCrc_u32GlbLvl2TstVar TST_Lvl2RamCrc_u32InitGlbLvl1TstVar TST_Lvl2RamCrc_u32InitGlbLvl2TstVar TST_Lvl2RamCrc_u32PwrOnClrGlbLvl2TstVar TST_Lvl2RamCrc_u32PwrOnInitGlbLvl2TstVar /end OUT_MEASUREMENT
/end FUNCTION
/begin FUNCTION MAIN "" FUNCTION_VERSION "NONE_"
 /begin DEF_CHARACTERISTIC MAIN_f32Trim2Nvm_def MAIN_s32Trim3Nvm_def MAIN_u32Trim1Nvm_def MAIN_u8FaultNvm_def /end DEF_CHARACTERISTIC
 /begin OUT_MEASUREMENT MAIN_f32Trim2Nvm MAIN_s16TestVar1 MAIN_s16TestVar2 MAIN_s16TestVar3 MAIN_s16TestVar4 MAIN_s32TestVar1 MAIN_s32TestVar2 MAIN_s32TestVar3 MAIN_s32TestVar4 MAIN_s32Trim3Nvm MAIN_s8TestVar1 MAIN_s8TestVar2 MAIN_s8TestVar3 MAIN_s8TestVar4 MAIN_u16TestIpduCtrl MAIN_u16TestIpduCtrlEna MAIN_u16TestIpduCtrlIdx MAIN_u16TestVar1 MAIN_u16TestVar2 MAIN_u16TestVar3 MAIN_u16TestVar4 MAIN_u16TskCtr1000msCpu0 MAIN_u16TskCtr1000msCpu1Lvl1 MAIN_u16TskCtr1000msCpu1Lvl2 MAIN_u16TskCtr1000msCpu1Lvl3 MAIN_u16TskCtr1000msCpu2 MAIN_u16TskCtr100msCpu0 MAIN_u16TskCtr100msCpu1Lvl1 MAIN_u16TskCtr100msCpu1Lvl2 MAIN_u16TskCtr100msCpu1Lvl3 MAIN_u16TskCtr100msCpu2 MAIN_u16TskCtr10msCpu0 MAIN_u16TskCtr10msCpu1Lvl1 MAIN_u16TskCtr10msCpu1Lvl2 MAIN_u16TskCtr10msCpu1Lvl3 MAIN_u16TskCtr10msCpu2 MAIN_u16TskCtr1msCpu0 MAIN_u16TskCtr1msCpu1Lvl1 MAIN_u16TskCtr1msCpu1Lvl2 MAIN_u16TskCtr1msCpu1Lvl3 MAIN_u16TskCtr1msCpu2 MAIN_u16TskCtr200msCpu0 MAIN_u16TskCtr200msCpu1Lvl1 MAIN_u16TskCtr200msCpu1Lvl2 MAIN_u16TskCtr200msCpu1Lvl3 MAIN_u16TskCtr200msCpu2 MAIN_u16TskCtr20msCpu0 MAIN_u16TskCtr20msCpu1Lvl1 MAIN_u16TskCtr20msCpu1Lvl2 MAIN_u16TskCtr20msCpu1Lvl3 MAIN_u16TskCtr20msCpu2 MAIN_u16TskCtr2msCpu0 MAIN_u16TskCtr2msCpu1Lvl1 MAIN_u16TskCtr2msCpu1Lvl2 MAIN_u16TskCtr2msCpu1Lvl3 MAIN_u16TskCtr2msCpu2 MAIN_u16TskCtr5000msCpu0 MAIN_u16TskCtr50msCpu0 MAIN_u16TskCtr50msCpu1Lvl1 MAIN_u16TskCtr50msCpu1Lvl2 MAIN_u16TskCtr50msCpu1Lvl3 MAIN_u16TskCtr50msCpu2 MAIN_u16TskCtr5msCpu0 MAIN_u16TskCtr5msCpu1Lvl1 MAIN_u16TskCtr5msCpu1Lvl2 MAIN_u16TskCtr5msCpu1Lvl3 MAIN_u16TskCtr5msCpu2 MAIN_u32TestVar1 MAIN_u32TestVar2 MAIN_u32TestVar3 MAIN_u32TestVar4 MAIN_u32Trim1Nvm MAIN_u8FaultNvm MAIN_u8FaultNvm[0] MAIN_u8FaultNvm[1] MAIN_u8FaultNvm[2] MAIN_u8FaultNvm[3] MAIN_u8FaultNvm[4] MAIN_u8FaultNvm[5] MAIN_u8FaultNvm[6] MAIN_u8FaultNvm[7] MAIN_u8FaultNvm[8] MAIN_u8FaultNvm[9] MAIN_u8TestVar1 MAIN_u8TestVar2 MAIN_u8TestVar3 MAIN_u8TestVar4 /end OUT_MEASUREMENT
/end FUNCTION
/begin FUNCTION PWD "" FUNCTION_VERSION "NONE_"
 /begin DEF_CHARACTERISTIC PWD_kudtTout_ENG_SPD_HALL_PWM PWD_kudtTout_ENG_SPD_VR_PWM PWD_kudtTout_INPUT_SPD_HALL_PWM PWD_kudtTout_INPUT_SPD_VR_PWM PWD_kudtTout_OUTPUT_SPD_HALL_PWM PWD_kudtTout_OUTPUT_SPD_VR_PWM PWD_kudtTout_PWM_IN_1 PWD_kudtTout_PWM_IN_2 PWD_kudtTout_PWM_IN_3 /end DEF_CHARACTERISTIC
 /begin OUT_MEASUREMENT PWD_bCurrentLvlIsActive_ENG_SPD_HALL_PWM PWD_bCurrentLvlIsActive_ENG_SPD_VR_PWM PWD_bCurrentLvlIsActive_INPUT_SPD_HALL_PWM PWD_bCurrentLvlIsActive_INPUT_SPD_VR_PWM PWD_bCurrentLvlIsActive_OUTPUT_SPD_HALL_PWM PWD_bCurrentLvlIsActive_OUTPUT_SPD_VR_PWM PWD_bCurrentLvlIsActive_PWM_IN_1 PWD_bCurrentLvlIsActive_PWM_IN_2 PWD_bCurrentLvlIsActive_PWM_IN_3 PWD_bEna_ENG_SPD_HALL_PWM PWD_bEna_ENG_SPD_VR_PWM PWD_bEna_INPUT_SPD_HALL_PWM PWD_bEna_INPUT_SPD_VR_PWM PWD_bEna_OUTPUT_SPD_HALL_PWM PWD_bEna_OUTPUT_SPD_VR_PWM PWD_bEna_PWM_IN_1 PWD_bEna_PWM_IN_2 PWD_bEna_PWM_IN_3 PWD_bEnableAll PWD_bFirstPerOccured_ENG_SPD_HALL_PWM PWD_bFirstPerOccured_ENG_SPD_VR_PWM PWD_bFirstPerOccured_INPUT_SPD_HALL_PWM PWD_bFirstPerOccured_INPUT_SPD_VR_PWM PWD_bFirstPerOccured_OUTPUT_SPD_HALL_PWM PWD_bFirstPerOccured_OUTPUT_SPD_VR_PWM PWD_bFirstPerOccured_PWM_IN_1 PWD_bFirstPerOccured_PWM_IN_2 PWD_bFirstPerOccured_PWM_IN_3 PWD_u16UpdateDisable PWD_udtDuty_ENG_SPD_HALL_PWM PWD_udtDuty_ENG_SPD_VR_PWM PWD_udtDuty_INPUT_SPD_HALL_PWM PWD_udtDuty_INPUT_SPD_VR_PWM PWD_udtDuty_OUTPUT_SPD_HALL_PWM PWD_udtDuty_OUTPUT_SPD_VR_PWM PWD_udtDuty_PWM_IN_1 PWD_udtDuty_PWM_IN_2 PWD_udtDuty_PWM_IN_3 PWD_udtPer_ENG_SPD_HALL_PWM PWD_udtPer_ENG_SPD_VR_PWM PWD_udtPer_INPUT_SPD_HALL_PWM PWD_udtPer_INPUT_SPD_VR_PWM PWD_udtPer_OUTPUT_SPD_HALL_PWM PWD_udtPer_OUTPUT_SPD_VR_PWM PWD_udtPer_PWM_IN_1 PWD_udtPer_PWM_IN_2 PWD_udtPer_PWM_IN_3 PWD_udtTout_ENG_SPD_HALL_PWM PWD_udtTout_ENG_SPD_VR_PWM PWD_udtTout_INPUT_SPD_HALL_PWM PWD_udtTout_INPUT_SPD_VR_PWM PWD_udtTout_OUTPUT_SPD_HALL_PWM PWD_udtTout_OUTPUT_SPD_VR_PWM PWD_udtTout_PWM_IN_1 PWD_udtTout_PWM_IN_2 PWD_udtTout_PWM_IN_3 PWD_udtToutRloadVal_ENG_SPD_HALL_PWM PWD_udtToutRloadVal_ENG_SPD_VR_PWM PWD_udtToutRloadVal_INPUT_SPD_HALL_PWM PWD_udtToutRloadVal_INPUT_SPD_VR_PWM PWD_udtToutRloadVal_OUTPUT_SPD_HALL_PWM PWD_udtToutRloadVal_OUTPUT_SPD_VR_PWM PWD_udtToutRloadVal_PWM_IN_1 PWD_udtToutRloadVal_PWM_IN_2 PWD_udtToutRloadVal_PWM_IN_3 /end OUT_MEASUREMENT
/end FUNCTION
/end MODULE
/end PROJECT
